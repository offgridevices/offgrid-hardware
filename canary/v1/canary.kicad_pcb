# Repository offgridevices/offgrid-hardware (continued)

## KiCad design products/mesh-radio/mesh-radio.kicad_pcb (continued)

Parts:
C9: 1uF; C_0603; MPN CL10B105KA8NNNC; DigiKey 1276-1184-1-ND
C10, C11: 10uF; C_0805; MPN CL21A106KAYNNNE; DigiKey 1276-2891-1-ND
C12, C13, C14: 100nF; C_0402; MPN CL05B104KO5NNNC; DigiKey 1276-1001-1-ND
D7: 4.7V; SOD-323FL; MPN UDZVTE-174.7B; LCSC C209560
D8: RB060MM-30; SOD-123FL; MPN RB060MM-30TR; DigiKey RB060MM-30CT-ND
J3: S2B-PH-SM4-TB(LF)(SN); CONN-SMD_P2.00_S2B-PH-SM4-TB-LF-SN; MPN S2B-PH-SM4-TB(LF)(SN); DigiKey 455-S2B-PH-SM4-TBCT-ND
LED1: red; LED0603-RD; MPN LTST-C191KRKT; DigiKey 160-1447-1-ND
Q1: CSD25310Q2T; WSON-6_DQK_CSD25310Q2; MPN CSD25310Q2T; DigiKey 296-50290-1-ND
Q2: SSM3K56ACT; SOT-883; MPN SSM3K56ACT,L3F; DigiKey SSM3K56ACTL3FCT-ND
Q3: SSM10N954L,EFF; CSP-10L_SSM10N954L; MPN SSM10N954L,EFF; DigiKey 264-SSM10N954LEFFCT-ND
R23, R28: 1k; R_0402; MPN RC0402FR-071KL; DigiKey 311-1.00KLRCT-ND
R24: 13k; R_0402; MPN RC0402FR-0713KL; DigiKey 311-13.0KLRCT-ND
R25, R31: 100k; R_0402; MPN RC0402FR-07100KL; DigiKey 311-100KLRCT-ND
R26, R27: 10k; R_0402; MPN RC0402FR-0710KL; DigiKey 311-10.0KLRCT-ND
R29, R30, R36: 1M; R_0402; MPN RC0402FR-071ML; DigiKey 311-1.00MLRCT-ND
R32: 330R; R_0402; MPN RC0402FR-07330RL; DigiKey 311-330LRCT-ND
R33: 2.2k; R_0402; MPN RC0402FR-072K2L; DigiKey 311-2.20KLRCT-ND
R34: 15mR; R_1206; MPN WSLP1206R0150FEA; DigiKey WSLP-.015CT-ND
R35: 1.15k; R_0402; MPN RC0402FR-071K15L; DigiKey YAG3033CT-ND
R37: 1.5M; R_0402; MPN RC0402FR-071M5L; DigiKey 13-RC0402FR-071M5LCT-ND
TH1: 10k NTC; R_0402; MPN NCU15XH103F60RC; DigiKey 490-18149-1-ND
U4: BQ25185DLHR; WSON-10_L2.2-W2.0-P0.40-BL-EP_TI_DLH0010A; MPN BQ25185DLHR; DigiKey 296-BQ25185DLHRCT-ND
U5: BQ29700DSER; WSON-6_L1.5-W1.5-P0.50-TL; MPN BQ29700DSER; DigiKey 296-43985-1-ND
U6: TPS22950YBHR; DSBGA-6_L1.2-W0.8-R2-C3-P0.40-BL; MPN TPS22950YBHR; DigiKey 296-TPS22950YBHRCT-ND

Connections:
3V3: R26.2, R27.2, R28.2; also elsewhere on the board
BATT_PLUS: J3.1, Q1.4 (D), Q1.8 (D (EP)), R30.1, R31.1
BAT_P: C11.1, Q1.1 (S), Q1.2 (S), Q1.5 (S), Q1.6 (S), Q1.7 (S (EP)), R29.2, R32.1, R36.1, U4.2 (BAT), U6.B1 (VIN); also elsewhere on the board
BYP_ILIM: R35.1, U6.C2 (ILIM)
BYP_OUT: D8.2 (A), U6.B2 (VOUT)
CELL_MINUS: C12.2, C13.2, D7.2 (A), J3.2, Q2.2 (S), Q3.1 (S1), Q3.2 (S1), Q3.4 (S1), Q3.5 (S1), R30.2, U5.4 (VSS)
CHG_CE_N: R25.1, U4.4 (~CE); also elsewhere on the board
CHG_ILIM: R24.1, U4.7 (ILIM/VSET)
CHG_ISET: R23.1, U4.8 (ISET)
CHG_LED_A: LED1.2 (A), R28.1
CHG_STAT1: R26.1, U4.9 (STAT1); also elsewhere on the board
CHG_STAT2: LED1.1 (K), R27.1, U4.3 (STAT2); also elsewhere on the board
CHG_TS: TH1.1, U4.6 (TS/MR); also elsewhere on the board
GND: C9.2, C10.2, C11.2, C14.2, R23.2, R24.2, R25.2, R33.2, R34.2, R35.2, R37.2, TH1.2, U4.5 (GND), U4.11 (GND (EP)), U6.C1 (GND); also elsewhere on the board
POL_G: C12.1, D7.1 (K), Q2.1 (G), R31.2
PROT_BAT: C13.1, R32.2, U5.5 (BAT)
PROT_COUT: Q3.8 (G2), U5.2 (COUT)
PROT_DOUT: Q3.3 (G1), U5.3 (DOUT)
PROT_S2: Q3.6 (S2), Q3.7 (S2), Q3.9 (S2), Q3.10 (S2), R34.1
PROT_VM: R33.1, U5.6 (V-)
PWR_ON: U6.A1 (ON); also elsewhere on the board
REV_G: Q1.3 (G), Q2.3 (D), R29.1
VBAT_SENSE: C14.1, R36.2, R37.1; also elsewhere on the board
VIN_CHG: C9.1, U4.10 (IN); also elsewhere on the board
VSYS: C10.1, D8.1 (K), U4.1 (SYS); also elsewhere on the board

Notes on the sheet:
Charger and battery: protection, reverse polarity, battery sense
Battery plug wired the Adafruit/SparkFun way (pad 1 = +). Cell protection on the minus side (OCD ~5.8 A, SCD ~29 A, OV 4.275 V, UV 2.8 V); reverse-battery P-FET on the plus side, on only when the cell is the right way round. Charge 300 mA. Current-limited cell-to-SYS bypass.

Parts:
C15: 1uF; C_0603; MPN CL10B105KA8NNNC; DigiKey 1276-1184-1-ND
C16, C18, C19: 10uF; C_0603; MPN CL10A106KP8NNNC; DigiKey 1276-1192-1-ND
C17: 4.7uF; C_0603; MPN CL10A475KP8NNNC; DigiKey 1276-1044-1-ND
L1: 2.2uH; L_0806; MPN DFE201610E-2R2M=P2; DigiKey 490-17728-1-ND
R38: 1M; R_0402; MPN RC0402FR-071ML; DigiKey 311-1.00MLRCT-ND
R39: 267k; R_0402; MPN RC0402FR-07267KL; DigiKey YAG3079CT-ND
SW1: JS202011JCQN; SW_DPDT_CK_JS202011JCQN; MPN JS202011JCQN; LCSC C221665
TP1, TP2, TP3: TP; TestPoint_Pad_1.0mm; MPN (copper pad)
U7: TPS62840YBGR; DSBGA-6_L1.4-W1.0-R2-C3-P0.40-BL; MPN TPS62840YBGR; DigiKey 296-TPS62840YBGRCT-ND

Connections:
3V3: C18.1, C19.1, L1.2, TP1.1, U7.A2 (VOS); also elsewhere on the board
BUCK_SW: L1.1, U7.B2 (SW)
BUCK_VSET: R39.1, U7.C2 (VSET)
GND: C15.2, C16.2, C17.2, C18.2, C19.2, R38.2, R39.2, TP2.1, U7.A1 (GND); also elsewhere on the board
PWR_ON: R38.1, SW1.2 (COM1), SW1.5 (COM2), U7.C1 (EN); also elsewhere on the board
VSYS: C15.1, C16.1, C17.1, SW1.1 (A1), SW1.4 (A2), TP3.1, U7.B1 (VIN); also elsewhere on the board

Notes on the sheet:
System power: on/off switch, 3.3 V rail
The slide switch drives only enables (3.3 V buck, cell bypass); charging works with the board off.

Parts:
AE1: 2450AT18A0100001E; ANT-SMD_L3.2-W1.6; MPN 2450AT18A0100001E; DigiKey 712-2450AT18A0100001ECT-ND
C20, C25, C31, C32: 4.7uF; C_0603; MPN CL10A475KP8NNNC; DigiKey 1276-1044-1-ND
C21, C26: 1uF; C_0402; MPN CL05A105KO5NNNC; DigiKey 1276-1067-1-ND
C22, C23, C24, C28: 100nF; C_0402; MPN CL05B104KO5NNNC; DigiKey 1276-1001-1-ND
C27: 47nF; C_0402; MPN CL05B473KO5NNNC; DigiKey 1276-1077-1-ND
C29: 100pF; C_0402; MPN GRM1555C1H101JA01D; DigiKey 490-5922-1-ND
C30: 820pF; C_0402; MPN GRM1555C1H821JA01D; DigiKey 490-3242-1-ND
C33, C34: 12pF; C_0402; MPN CL05C120JB5NNNC; DigiKey 1276-1178-1-ND
C35, C36: 10pF; C_0402; MPN GJM1555C1H100JB01D; DigiKey 490-3113-1-ND
C37: 0.8pF; C_0402; MPN GJM1555C1HR80WB01D; DigiKey 490-11253-1-ND
C38: 0.9pF; C_0402; MPN GJM1555C1HR90WB01D; LCSC C161350
C39: 1.6pF; C_0402; MPN GJM1555C1H1R6BB01D; LCSC C161311
L2: 10uH; L_0805; MPN MLZ2012M100WT000; DigiKey 445-6396-1-ND
L3: 15nH; L_0402; MPN LQW15AN15NJ00D; DigiKey 490-1148-1-ND
L4: 3.9nH; L_0402; MPN LQW15AN3N9C00D; DigiKey 490-6813-1-ND
L5: 1.5nH; L_0402; MPN LQW15AN1N5C00D; LCSC C167468
L6: 2.7nH; L_0402; MPN LQW15AN2N7C00D; DigiKey 490-6800-1-ND
R40, R41: 22R; R_0402; MPN RC0402FR-0722RL; DigiKey 311-22.0LRCT-ND
TP4, TP5, TP6: TP; TestPoint_Pad_1.0mm; MPN (copper pad)
U8: NRF52840-QIAA-F-R7; AQFN-73_L7.0-W7.0-P0.50-BL-EP4.8; MPN NRF52840-QIAA-F-R7; DigiKey 4823-NRF52840-QIAA-F-R7CT-ND
Y1: 32MHz; CRYSTAL-SMD_4P-L2.0-W1.6-BL_CXAN-211; MPN ABM11W-32.0000MHZ-8-D1X-T3; DigiKey 535-13900-1-ND
Y2: 32.768kHz; ABS07; MPN ABS07-32.768KHZ-7-T; DigiKey 535-9543-1-ND

Connections:
3V3: C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, U8.A22 (VDD), U8.AD14 (VDD), U8.AD23 (VDD), U8.B1 (VDD), U8.W1 (VDD), U8.Y2 (VDDH); also elsewhere on the board
BLE_50R: C38.1, C39.1, L4.2
BLE_FEED: AE1.1 (FEED), L6.2
BLE_T: C39.2, L5.1, L6.1
BTN_USER: U8.AD22 (P1.00); also elsewhere on the board
CHG_CE_N: U8.L24 (P0.09/NFC1); also elsewhere on the board
CHG_STAT1: U8.AD20 (P0.24); also elsewhere on the board
CHG_STAT2: U8.AC21 (P0.25); also elsewhere on the board
CHG_TS: U8.A8 (P0.31/AIN7); also elsewhere on the board
DISP_BL: U8.P2 (P1.08); also elsewhere on the board
DISP_CS: U8.U1 (P0.12); also elsewhere on the board
DISP_DC: U8.G1 (P0.26); also elsewhere on the board
DISP_MOSI: U8.N1 (P0.08); also elsewhere on the board
DISP_RST: U8.H2 (P0.27); also elsewhere on the board
DISP_SCK: U8.M2 (P0.07); also elsewhere on the board
DRONE_CTS: U8.AC17 (P0.21); also elsewhere on the board
DRONE_OK: U8.B13 (P0.03/AIN1); also elsewhere on the board
DRONE_RTS: U8.AD18 (P0.22); also elsewhere on the board
DRONE_RX: U8.AD10 (P0.15); also elsewhere on the board
DRONE_TX: U8.AC11 (P0.16); also elsewhere on the board
FWD_DET: U8.A12 (P0.02/AIN0); also elsewhere on the board
GND: C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, L5.2, U8.0 (VSS (EP)), U8.B7 (VSS), U8.F23 (VSS_PA), Y1.2 (G); also elsewhere on the board
GPS_EN: U8.AC19 (P0.23); also elsewhere on the board
GPS_PPS: U8.AD12 (P0.17); also elsewhere on the board
GPS_RX: U8.AC15 (P0.19); also elsewhere on the board
GPS_TX: U8.AD16 (P0.20); also elsewhere on the board
I2C_SCL: U8.AC9 (P0.14); also elsewhere on the board
I2C_SDA: U8.AD8 (P0.13); also elsewhere on the board
LED_BLUE: U8.U24 (P1.04); also elsewhere on the board
LED_GREEN: U8.V23 (P1.03); also elsewhere on the board
LNA_EN: U8.T23 (P1.05); also elsewhere on the board
LORA_BUSY: U8.B15 (P1.14); also elsewhere on the board
LORA_DIO1: U8.A14 (P1.15); also elsewhere on the board
LORA_MISO: U8.A16 (P1.13); also elsewhere on the board
LORA_MOSI: U8.B17 (P1.12); also elsewhere on the board
LORA_NRESET: U8.R24 (P1.06); also elsewhere on the board
LORA_NSS: U8.A20 (P1.10); also elsewhere on the board
LORA_SCK: U8.B19 (P1.11); also elsewhere on the board
NRF_ANT: C37.1, L4.1, U8.H23 (ANT)
NRF_DCC: L2.1, U8.B3 (DCC)
NRF_DCC_L: L2.2, L3.1
NRF_DEC1: C28.1, U8.C1 (DEC1)
NRF_DEC3: C29.1, U8.D23 (DEC3)
NRF_DEC4: C26.1, C27.1, L3.2, U8.B5 (DEC4), U8.E24 (DEC6)
NRF_DEC5: C30.1, U8.N24 (DEC5)
NRF_DECUSB: C32.1, U8.AC5 (DECUSB)
NRF_DM: R41.2, U8.AD4 (D-)
NRF_DP: R40.2, U8.AD6 (D+)
NRF_RESET: TP6.1, U8.AC13 (P0.18/nRESET); also elsewhere on the board
NRF_VBUS: C31.1, U8.AD2 (VBUS); also elsewhere on the board
PA_EN: U8.P23 (P1.07); also elsewhere on the board
PA_PWR_EN: U8.Y23 (P1.01); also elsewhere on the board
PA_SRC_SYS: U8.R1 (P1.09); also elsewhere on the board
REFL_DET: U8.B9 (P0.30/AIN6); also elsewhere on the board
SOLAR_OK: U8.J1 (P0.04/AIN2); also elsewhere on the board
SWDCLK: TP5.1, U8.AA24 (SWDCLK)
SWDIO: TP4.1, U8.AC24 (SWDIO)
TEMP_ALERT: U8.L1 (P0.06); also elsewhere on the board
USB_DM: R41.1; also elsewhere on the board
USB_DP: R40.1; also elsewhere on the board
VBAT_SENSE: U8.K2 (P0.05/AIN3); also elsewhere on the board
XC1: C33.1, U8.B24 (XC1), Y1.1
XC2: C34.1, U8.A23 (XC2), Y1.3
XL1: C35.1, U8.D2 (P0.00/XL1), Y2.1
XL2: C36.1, U8.F2 (P0.01/XL2), Y2.2

Notes on the sheet:
Processor and Bluetooth: nRF52840
nRF52840 in normal-voltage mode: VDD = VDDH = the 3.3 V rail, so its pins and the SX1262 share one logic level. REG1 DC/DC on (10 uH + 15 nH). Nordic reference circuit, aQFN73.

Parts:
C40: 1uF; C_0402; MPN CL05A105KO5NNNC; DigiKey 1276-1067-1-ND
C41, C42, C44: 100nF; C_0402; MPN CL05B104KO5NNNC; DigiKey 1276-1001-1-ND
C43: 470nF; C_0402; MPN CL05A474KO5NNNC; DigiKey 1276-CL05A474KO5NNNCCT-ND
C45: 10pF; C_0402; MPN GJM1555C1H100JB01D; DigiKey 490-3113-1-ND
C46: 47nF; C_0402; MPN CL05B473KO5NNNC; DigiKey 1276-1077-1-ND
C47: 47pF; C_0402; MPN GJM1555C1H470JB01D; DigiKey 490-14446-1-ND
C48: 3.0pF; C_0402; MPN GJM1555C1H3R0BB01D; DigiKey 490-8095-1-ND
C49: 5.6pF; C_0402; MPN GJM1555C1H5R6BB01D; DigiKey 490-11225-1-ND
C50: 39pF; C_0402; MPN GJM1555C1H390JB01D; DigiKey 490-17673-1-ND
C51, C53: 1.8pF; C_0402; MPN GJM1555C1H1R8BB01D; DigiKey 490-8089-1-ND
C52: 2.4pF; C_0402; MPN GJM1555C1H2R4BB01D; DigiKey 490-8093-1-ND
L7: 15uH; L_0805; MPN MLZ2012M150WT000; DigiKey 445-6397-1-ND
L8: 47nH; L_0402; MPN LQW15AN47NJ00D; DigiKey 490-1154-1-ND
L9: 2.5nH; L_0402; MPN LQW15AN2N5C00D; DigiKey 490-6798-1-ND
L10: 4.7nH; L_0402; MPN LQW15AN4N7C00D; DigiKey 490-1139-1-ND
L11: 15nH; L_0402; MPN LQW15AN15NJ00D; DigiKey 490-1148-1-ND
R42: 220R; R_0402; MPN RC0402FR-07220RL; DigiKey 311-220LRCT-ND
R43: 0R; R_0402; MPN RC0402FR-070RL; DigiKey 311-0.0LRCT-ND
R44: 4.7k; R_0402; MPN RC0402FR-074K7L; DigiKey 311-4.7KLRCT-ND
R45: 10k; R_0402; MPN RC0402FR-0710KL; DigiKey 311-10.0KLRCT-ND
U9: SX1262IMLTRT; QFN-24_L4.0-W4.0-P0.50-BL-EP2.6; MPN SX1262IMLTRT; DigiKey SX1262IMLTRTCT-ND
Y3: ECS-TXO-20CSMV4-320-AP-TR; OSC-SMD_4P-L2.0-W1.6-BL; MPN ECS-TXO-20CSMV4-320-AP-TR; DigiKey 50-ECS-TXO-20CSMV4-320-AP-TRCT-ND

Connections:
3V3: C40.1, C41.1, C42.1, U9.1 (VDD_IN), U9.10 (VBAT), U9.11 (VBAT_IO); also elsewhere on the board
GND: C40.2, C41.2, C42.2, C43.2, C44.2, C46.2, C47.2, C49.2, C51.2, C53.2, R45.2, U9.2 (GND), U9.5 (GND), U9.8 (GND), U9.20 (GND), U9.25 (GND (EP)), Y3.1 (GND), Y3.2 (GND); also elsewhere on the board
LNA_OUT: C52.1; also elsewhere on the board
LORA_BUSY: U9.14 (BUSY); also elsewhere on the board
LORA_DCC: L7.1, U9.9 (DCC_SW)
LORA_DIO1: U9.13 (DIO1); also elsewhere on the board
LORA_DIO2: R44.1, U9.12 (DIO2)
LORA_DIO3: C44.1, U9.6 (DIO3), Y3.4 (VDD)
LORA_MISO: U9.16 (MISO); also elsewhere on the board
LORA_MOSI: U9.17 (MOSI); also elsewhere on the board
LORA_NRESET: U9.15 (NRESET); also elsewhere on the board
LORA_NSS: U9.19 (NSS); also elsewhere on the board
LORA_RFI_N: C52.2, L11.1, U9.22 (RFI_N)
LORA_RFI_P: C53.1, L11.2, U9.21 (RFI_P)
LORA_RFO: L8.2, R43.1, U9.23 (RFO)
LORA_SCK: U9.18 (SCK); also elsewhere on the board
LORA_TX50: C51.1, L10.2; also elsewhere on the board
LORA_TXA: C48.1, L9.1, R43.2
LORA_TXB: C48.2, C49.1, C50.1, L9.2
LORA_TXC: C50.2, L10.1
LORA_VREG: C43.1, L7.2, U9.7 (VREG)
LORA_VRPA: C46.1, C47.1, L8.1, U9.24 (VR_PA)
LORA_XTA: C45.2, U9.3 (XTA)
RF_SW_CTRL: R44.2, R45.1; also elsewhere on the board
TCXO_AC: C45.1, R42.2
TCXO_OUT: R42.1, Y3.3 (OUT)

Notes on the sheet:
LoRa radio: SX1262, its clock, transmit match and receive balun
Semtech SX1262MB2CAS (915 MHz) reference values. TCXO on DIO3 (set 2.2 V in firmware), DIO2 drives the antenna switch.
