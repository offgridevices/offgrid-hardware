# Repository offgridevices/offgrid-hardware (continued)

## KiCad design products/ridge/ridge-3-lite/ridge3-lite.kicad_pcb

Board: 8 copper layers, 38.0 x 38.0 mm, 260 parts (88 on the bottom side), 188 nets.

Parts:
C1, C8, C10, C11, C104, C106, C108, C204, C206, C208, C304, C306, C308, C404, C406, C408: 4.7uF; C_0805_2012Metric
C2, C3: 100nF; C_0402_1005Metric_L
C4, C7, C9, C103, C105, C107, C203, C205, C207, C303, C305, C307, C403, C405, C407: 1uF; C_0402_1005Metric_L
C5, C6: 22uF; C_0805_2012Metric
C12, C102, C202, C302, C402: 10uF; C_0603_1608Metric_L
C13, C14, C15, C16, C17, C18, C19, C22, C26, C27, C101, C109, C110, C111, C201, C209, C210, C211, C301, C309, C310, C311, C401, C409, C410, C411: 100nF; C_0201_0603Metric_L
C20: 1uF; C_0201_0603Metric_L
C21, C25: 4.7uF; C_0402_1005Metric_L
C23, C24: 12pF; C_0402_1005Metric_L
D_TVS: SMF22A; SOD-123FL_L2.8-W1.9-LS3.7-RD
D_USB: SS1040HE; SOD-323HE_L2.0-W1.4-LS2.5-RD
H1, H2, H3, H4: HOLE; MOUNT_M2
J_USB: USB-C; USB-C-SMD_TYPE-C-16P-USB4110-GF-A
LED_PWR: red; LED0603-RD
LED_STAT: blue; LED0603-RD
L_BEC: 10uH; IND-SMD_L3.0-W3.0_SWPA3010S
P_5V: PAD_SIG
P_BAT+: PAD_BAT
P_BAT-: PAD_BAT
P_BZ+: PAD_SIG
P_BZ-: PAD_SIG
P_G: PAD_SIG
P_LED: PAD_SIG
P_M1A, P_M1B, P_M1C, P_M2A, P_M2B, P_M2C, P_M3A, P_M3B, P_M3C, P_M4A, P_M4B, P_M4C: PAD_MOTOR
P_R1, P_R2: PAD_SIG
P_T1, P_T2: PAD_SIG
Q1AH, Q1AL, Q1BH, Q1BL, Q1CH, Q1CL, Q2AH, Q2AL, Q2BH, Q2BL, Q2CH, Q2CL, Q3AH, Q3AL, Q3BH, Q3BL, Q3CH, Q3CL, Q4AH, Q4AL, Q4BH, Q4BL, Q4CH, Q4CL: TPN2R304PL; TSON-8_L3.1-W3.1-P0.65-LS3.3-BL-EP
Q_BZ: AO3400A; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR
R1, R119, R219, R319, R419: 100k; R_0402_1005Metric_L
R2: 27k; R_0201_0603Metric_L
R3: 10R; R_0402_1005Metric_L
R4: 82k; R_0402_1005Metric_L
R5, R9, R16, R105, R110, R115, R118, R120, R205, R210, R215, R218, R220, R305, R310, R315, R318, R320, R405, R410, R415, R418, R420: 10k; R_0201_0603Metric_L
R6, R103, R108, R113, R203, R208, R213, R303, R308, R313, R403, R408, R413: 10k; R_0402_1005Metric_L
R7, R13, R117, R217, R317, R417: 1k; R_0201_0603Metric_L
R8: 62k; R_0201_0603Metric_L
R10, R102, R107, R112, R202, R207, R212, R302, R307, R312, R402, R407, R412: 10R; R_0201_0603Metric_L
R11, R12: 5.1k; R_0201_0603Metric_L
R14: 330R; R_0201_0603Metric_L
R15: 100R; R_0201_0603Metric_L
R101, R106, R111, R201, R206, R211, R301, R306, R311, R401, R406, R411: 22R; R_0201_0603Metric_L
R104, R109, R114, R204, R209, R214, R304, R309, R314, R404, R409, R414: 2.2k; R_0201_0603Metric_L
R116, R216, R316, R416: 1.5k; R_0201_0603Metric_L
R_S1, R_S2, R_S3, R_S4: 0.5mOhm; RES-SMD_1206_HCS1206
SW_BOOT: BOOT; KEY-SMD_B3U-1000PM
TP_3V3: PAD_TP
TP_C1, TP_C2, TP_C3, TP_C4: PAD_TP
TP_D1, TP_D2, TP_D3, TP_D4: PAD_TP
TP_GND: PAD_TP
U_A1, U_A2, U_A3, U_A4: INA186A3; SC-70-6_L2.0-W1.3-P0.65-LS2.1-BL-1
U_BEC: LMR36506R5; VQFN-9_L2.1-W2.1-P0.50-TL
U_D1, U_D2, U_D3, U_D4: DRV8300DRGER; VQFN-24_L4.0-W4.0-P0.50-TL-EP2.5
U_E1, U_E2, U_E3, U_E4: STM32G071GBU6; UFQFPN-28_L4.0-W4.0-P0.50-BL
U_ESD: USBLC6-2SC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL
U_FC: STM32G473CEU6; UFQFPN-48_L7.0-W7.0-P0.50-BL-EP5.6
U_GVDD: TPS7A1601; SON-8_L3.0-W3.0-P0.65-TL-EP
U_IMU: ICM-42688-P; LGA-14_L3.0-W2.5-P0.50-TL
U_LDO: TLV76733; WSON-6_L2.0-W2.0-P0.65-TL-EP
U_LDOE: TLV76733; WSON-6_L2.0-W2.0-P0.65-TL-EP
Y1: 8 MHz; CRYSTAL-SMD_4P-L3.2-W2.5-BL

Connections:
+3V3: C8.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, R10.1, R13.1, R14.1, SW_BOOT.1, U_FC.1, U_FC.20, U_FC.21, U_FC.23, U_FC.35, U_FC.48, U_LDO.1, U_LDO.2
+3V3E: C10.1, C101.1, C109.1, C201.1, C209.1, C301.1, C309.1, C401.1, C409.1, TP_3V3.1, U_A1.3, U_A2.3, U_A3.3, U_A4.3, U_E1.3, U_E2.3, U_E3.3, U_E4.3, U_LDOE.1, U_LDOE.2
+3V3_GYRO: C25.1, C26.1, C27.1, R10.2, U_IMU.5, U_IMU.8
+5V: C5.1, C6.1, C7.1, C9.1, D_USB.1, L_BEC.2, P_5V.1, P_BZ+.1, U_BEC.8, U_LDO.4, U_LDO.6, U_LDOE.4, U_LDOE.6
ADC_VBAT: C13.1, R6.2, R7.1, U_FC.19
BEC_BOOT: C3.1, U_BEC.6
BEC_EN: R1.2, R2.1, U_BEC.3
BEC_SW: C3.2, L_BEC.1, U_BEC.5
BEC_VCC: C4.1, U_BEC.7
BEEPER: R15.1, U_FC.38
BEEPER_G: Q_BZ.1, R15.2, R16.1
BOOT0: R9.1, SW_BOOT.2, U_FC.46
BZ-: P_BZ-.1, Q_BZ.3
CUR: C14.1, R8.1, R118.2, R218.2, R318.2, R418.2, U_FC.18
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C101.2, C102.2, C109.2, C110.2, C111.2, C201.2, C202.2, C209.2, C210.2, C211.2, C301.2, C302.2, C309.2, C310.2, C311.2, C401.2, C402.2, C409.2, C410.2, C411.2, D_TVS.2, J_USB.8, J_USB.9, J_USB.10, J_USB.11, J_USB.A1B12, J_USB.B1A12, LED_PWR.1, P_BAT-.1, P_G.1, Q_BZ.2, R2.2, R5.2, R7.2, R8.2, R9.2, R11.2, R12.2, R16.2, R104.2, R109.2, R114.2, R117.2, R120.2, R204.2, R209.2, R214.2, R217.2, R220.2, R304.2, R309.2, R314.2, R317.2, R320.2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
GVDD: C12.1, C102.1, C202.1, C302.1, C402.1, R4.1, U_D1.4, U_D2.4, U_D3.4, U_D4.4, U_GVDD.1
GVDD_FB: R4.2, R5.1, U_GVDD.2
GVDD_IN: C11.1, R3.2, U_GVDD.5, U_GVDD.8
GYRO_CS: U_FC.17, U_IMU.12
GYRO_INT: U_FC.12, U_IMU.4
HSE_IN: C23.1, U_FC.5, Y1.1
HSE_OUT: C24.1, U_FC.6, Y1.3
LED0: LED_STAT.1, U_FC.45
LED0_A: LED_STAT.2, R14.2
LED_PWR_A: LED_PWR.2, R13.2
LED_STRIP: P_LED.1, U_FC.44
M1_A: C103.2, P_M1A.1, Q1AH.1, Q1AH.2, Q1AH.3, Q1AL.5, Q1AL.6, Q1AL.7, Q1AL.8, Q1AL.9, R103.1, U_D1.18
M1_B: C105.2, P_M1B.1, Q1BH.1, Q1BH.2, Q1BH.3, Q1BL.5, Q1BL.6, Q1BL.7, Q1BL.8, Q1BL.9, R108.1, U_D1.15
M1_BSTA: C103.1, U_D1.20
M1_BSTB: C105.1, U_D1.17
M1_BSTC: C107.1, U_D1.14
M1_C: C107.2, P_M1C.1, Q1CH.1, Q1CH.2, Q1CH.3, Q1CL.5, Q1CL.6, Q1CL.7, Q1CL.8, Q1CL.9, R113.1, U_D1.12
M1_CMP_A: R103.2, R104.1, R105.1, U_E1.27
M1_CMP_B: R108.2, R109.1, R110.1, U_E1.23
M1_CMP_C: R113.2, R114.1, R115.1, U_E1.8
M1_GHA: Q1AH.4, R101.2
M1_GHA_D: R101.1, U_D1.19
M1_GHB: Q1BH.4, R106.2
M1_GHB_D: R106.1, U_D1.16
M1_GHC: Q1CH.4, R111.2
M1_GHC_D: R111.1, U_D1.13
M1_GLA: Q1AL.4, R102.2
M1_GLA_D: R102.1, U_D1.11
M1_GLB: Q1BL.4, R107.2
M1_GLB_D: R107.1, U_D1.10
M1_GLC: Q1CL.4, R112.2
M1_GLC_D: R112.1, U_D1.9
M1_HA: U_D1.22, U_E1.19
M1_HB: U_D1.23, U_E1.18
M1_HC: U_D1.24, U_E1.16
M1_IOUT: R116.1, R118.1, U_A1.6
M1_ISENSE: C110.1, R116.2, R117.1, U_E1.11
M1_LA: U_D1.1, U_E1.15
M1_LB: U_D1.2, U_E1.14
M1_LC: U_D1.3, U_E1.13
M1_NEUTRAL: R105.2, R110.2, R115.2, U_E1.9
M1_SIG: U_E1.24, U_FC.8
M1_SNSN: R_S1.4, U_A1.5
M1_SNSP: R_S1.3, U_A1.4
M1_SRC: C104.2, C106.2, C108.2, Q1AL.1, Q1AL.2, Q1AL.3, Q1BL.1, Q1BL.2, Q1BL.3, Q1CL.1, Q1CL.2, Q1CL.3, R_S1.1
M1_SWCLK: TP_C1.1, U_E1.21
M1_SWDIO: TP_D1.1, U_E1.20
M1_VSENSE: C111.1, R119.2, R120.1, U_E1.12
M2_A: C203.2, P_M2A.1, Q2AH.1, Q2AH.2, Q2AH.3, Q2AL.5, Q2AL.6, Q2AL.7, Q2AL.8, Q2AL.9, R203.1, U_D2.18
M2_B: C205.2, P_M2B.1, Q2BH.1, Q2BH.2, Q2BH.3, Q2BL.5, Q2BL.6, Q2BL.7, Q2BL.8, Q2BL.9, R208.1, U_D2.15
M2_BSTA: C203.1, U_D2.20
M2_BSTB: C205.1, U_D2.17
M2_BSTC: C207.1, U_D2.14
M2_C: C207.2, P_M2C.1, Q2CH.1, Q2CH.2, Q2CH.3, Q2CL.5, Q2CL.6, Q2CL.7, Q2CL.8, Q2CL.9, R213.1, U_D2.12
M2_CMP_A: R203.2, R204.1, R205.1, U_E2.27
M2_CMP_B: R208.2, R209.1, R210.1, U_E2.23
M2_CMP_C: R213.2, R214.1, R215.1, U_E2.8
M2_GHA: Q2AH.4, R201.2
M2_GHA_D: R201.1, U_D2.19
M2_GHB: Q2BH.4, R206.2
M2_GHB_D: R206.1, U_D2.16
M2_GHC: Q2CH.4, R211.2
M2_GHC_D: R211.1, U_D2.13
M2_GLA: Q2AL.4, R202.2
M2_GLA_D: R202.1, U_D2.11
M2_GLB: Q2BL.4, R207.2
M2_GLB_D: R207.1, U_D2.10
M2_GLC: Q2CL.4, R212.2
M2_GLC_D: R212.1, U_D2.9
M2_HA: U_D2.22, U_E2.19
M2_HB: U_D2.23, U_E2.18
M2_HC: U_D2.24, U_E2.16
M2_IOUT: R216.1, R218.1, U_A2.6
M2_ISENSE: C210.1, R216.2, R217.1, U_E2.11
M2_LA: U_D2.1, U_E2.15
M2_LB: U_D2.2, U_E2.14
M2_LC: U_D2.3, U_E2.13
M2_NEUTRAL: R205.2, R210.2, R215.2, U_E2.9
M2_SIG: U_E2.24, U_FC.9
M2_SNSN: R_S2.4, U_A2.5
M2_SNSP: R_S2.3, U_A2.4
M2_SRC: C204.2, C206.2, C208.2, Q2AL.1, Q2AL.2, Q2AL.3, Q2BL.1, Q2BL.2, Q2BL.3, Q2CL.1, Q2CL.2, Q2CL.3, R_S2.1
M2_SWCLK: TP_C2.1, U_E2.21
M2_SWDIO: TP_D2.1, U_E2.20
M2_VSENSE: C211.1, R219.2, R220.1, U_E2.12
M3_A: C303.2, P_M3A.1, Q3AH.1, Q3AH.2, Q3AH.3, Q3AL.5, Q3AL.6, Q3AL.7, Q3AL.8, Q3AL.9, R303.1, U_D3.18
M3_B: C305.2, P_M3B.1, Q3BH.1, Q3BH.2, Q3BH.3, Q3BL.5, Q3BL.6, Q3BL.7, Q3BL.8, Q3BL.9, R308.1, U_D3.15
M3_BSTA: C303.1, U_D3.20
M3_BSTB: C305.1, U_D3.17
M3_BSTC: C307.1, U_D3.14
M3_C: C307.2, P_M3C.1, Q3CH.1, Q3CH.2, Q3CH.3, Q3CL.5, Q3CL.6, Q3CL.7, Q3CL.8, Q3CL.9, R313.1, U_D3.12
M3_CMP_A: R303.2, R304.1, R305.1, U_E3.27
M3_CMP_B: R308.2, R309.1, R310.1, U_E3.23
M3_CMP_C: R313.2, R314.1, R315.1, U_E3.8
M3_GHA: Q3AH.4, R301.2
M3_GHA_D: R301.1, U_D3.19
M3_GHB: Q3BH.4, R306.2
M3_GHB_D: R306.1, U_D3.16
M3_GHC: Q3CH.4, R311.2
M3_GHC_D: R311.1, U_D3.13
M3_GLA: Q3AL.4, R302.2
M3_GLA_D: R302.1, U_D3.11
M3_GLB: Q3BL.4, R307.2
M3_GLB_D: R307.1, U_D3.10
M3_GLC: Q3CL.4, R312.2
M3_GLC_D: R312.1, U_D3.9
M3_HA: U_D3.22, U_E3.19
M3_HB: U_D3.23, U_E3.18
M3_HC: U_D3.24, U_E3.16
M3_IOUT: R316.1, R318.1, U_A3.6
M3_ISENSE: C310.1, R316.2, R317.1, U_E3.11
M3_LA: U_D3.1, U_E3.15
M3_LB: U_D3.2, U_E3.14
M3_LC: U_D3.3, U_E3.13
M3_NEUTRAL: R305.2, R310.2, R315.2, U_E3.9
M3_SIG: U_E3.24, U_FC.10
M3_SNSN: R_S3.4, U_A3.5
M3_SNSP: R_S3.3, U_A3.4
M3_SRC: C304.2, C306.2, C308.2, Q3AL.1, Q3AL.2, Q3AL.3, Q3BL.1, Q3BL.2, Q3BL.3, Q3CL.1, Q3CL.2, Q3CL.3, R_S3.1
M3_SWCLK: TP_C3.1, U_E3.21
M3_SWDIO: TP_D3.1, U_E3.20
M3_VSENSE: C311.1, R319.2, R320.1, U_E3.12
M4_A: C403.2, P_M4A.1, Q4AH.1, Q4AH.2, Q4AH.3, Q4AL.5, Q4AL.6, Q4AL.7, Q4AL.8, Q4AL.9, R403.1, U_D4.18
M4_B: C405.2, P_M4B.1, Q4BH.1, Q4BH.2, Q4BH.3, Q4BL.5, Q4BL.6, Q4BL.7, Q4BL.8, Q4BL.9, R408.1, U_D4.15
M4_BSTA: C403.1, U_D4.20
M4_BSTB: C405.1, U_D4.17
M4_BSTC: C407.1, U_D4.14
M4_C: C407.2, P_M4C.1, Q4CH.1, Q4CH.2, Q4CH.3, Q4CL.5, Q4CL.6, Q4CL.7, Q4CL.8, Q4CL.9, R413.1, U_D4.12
M4_CMP_A: R403.2, R404.1, R405.1, U_E4.27
M4_CMP_B: R408.2, R409.1, R410.1, U_E4.23
M4_CMP_C: R413.2, R414.1, R415.1, U_E4.8
M4_GHA: Q4AH.4, R401.2
M4_GHA_D: R401.1, U_D4.19
M4_GHB: Q4BH.4, R406.2
M4_GHB_D: R406.1, U_D4.16
M4_GHC: Q4CH.4, R411.2
M4_GHC_D: R411.1, U_D4.13
M4_GLA: Q4AL.4, R402.2
M4_GLA_D: R402.1, U_D4.11
M4_GLB: Q4BL.4, R407.2
M4_GLB_D: R407.1, U_D4.10
M4_GLC: Q4CL.4, R412.2
M4_GLC_D: R412.1, U_D4.9
M4_HA: U_D4.22, U_E4.19
M4_HB: U_D4.23, U_E4.18
M4_HC: U_D4.24, U_E4.16
M4_IOUT: R416.1, R418.1, U_A4.6
M4_ISENSE: C410.1, R416.2, R417.1, U_E4.11
M4_LA: U_D4.1, U_E4.15
M4_LB: U_D4.2, U_E4.14
M4_LC: U_D4.3, U_E4.13
M4_NEUTRAL: R405.2, R410.2, R415.2, U_E4.9
M4_SIG: U_E4.24, U_FC.11
M4_SNSN: R_S4.4, U_A4.5
M4_SNSP: R_S4.3, U_A4.4
M4_SRC: C404.2, C406.2, C408.2, Q4AL.1, Q4AL.2, Q4AL.3, Q4BL.1, Q4BL.2, Q4BL.3, Q4CL.1, Q4CL.2, Q4CL.3, R_S4.1
M4_SWCLK: TP_C4.1, U_E4.21
M4_SWDIO: TP_D4.1, U_E4.20
M4_VSENSE: C411.1, R419.2, R420.1, U_E4.12
NRST: C22.1, U_FC.7
SPI1_MISO: U_FC.14, U_IMU.1
SPI1_MOSI: U_FC.15, U_IMU.14
SPI1_SCK: U_FC.13, U_IMU.13
UART1_RX: P_R1.1, U_FC.32
UART1_TX: P_T1.1, U_FC.31
UART2_RX: P_R2.1, U_FC.42
UART2_TX: P_T2.1, U_FC.41
USB_CC1: J_USB.A5, R11.1
USB_CC2: J_USB.B5, R12.1
USB_DM: J_USB.A7, J_USB.B7, U_ESD.3, U_ESD.4, U_FC.33
USB_DP: J_USB.A6, J_USB.B6, U_ESD.1, U_ESD.6, U_FC.34
USB_VBUS: D_USB.2, J_USB.A4B9, J_USB.B4A9, U_ESD.5
VBAT: C1.1, C2.1, C104.1, C106.1, C108.1, C204.1, C206.1, C208.1, C304.1, C306.1, C308.1, C404.1, C406.1, C408.1, D_TVS.1, P_BAT+.1, Q1AH.5, Q1AH.6, Q1AH.7, Q1AH.8, Q1AH.9, Q1BH.5, Q1BH.6, Q1BH.7, Q1BH.8, Q1BH.9, Q1CH.5, Q1CH.6, Q1CH.7, Q1CH.8, Q1CH.9, Q2AH.5, Q2AH.6, Q2AH.7, Q2AH.8, Q2AH.9, Q2BH.5, Q2BH.6, Q2BH.7, Q2BH.8, Q2BH.9, Q2CH.5, Q2CH.6, Q2CH.7, Q2CH.8, Q2CH.9, Q3AH.5, Q3AH.6, Q3AH.7, Q3AH.8, Q3AH.9, Q3BH.5, Q3BH.6, Q3BH.7, Q3BH.8, Q3BH.9, Q3CH.5, Q3CH.6, Q3CH.7, Q3CH.8, Q3CH.9, Q4AH.5, Q4AH.6, Q4AH.7, Q4AH.8, Q4AH.9, Q4BH.5, Q4BH.6, Q4BH.7, Q4BH.8, Q4BH.9, Q4CH.5, Q4CH.6, Q4CH.7, Q4CH.8, Q4CH.9, R1.1, R3.1, R6.1, R119.1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

## KiCad design products/ridge/ridge-3/fc/ridge3-fc.kicad_pcb

Board: 6 copper layers, 36.0 x 36.0 mm, 124 parts (51 on the bottom side), 70 nets.

Parts:
C1, C2, C5, C10, C11, C19, C20, C21, C22, C23, C26, C30, C31, C32, C34, C35, C36, C37: 100nF; C_0402_1005Metric
C3, C8: 10uF; C_1210_3225Metric
C4, C9: 100nF; C_0603_1608Metric
C6, C7, C12, C13: 22uF; C_1210_3225Metric
C14, C17: 10uF; C_0805_2012Metric
C15, C16, C25, C29, C33: 4.7uF; C_0603_1608Metric
C18, C27, C28: 10pF; C_0402_1005Metric
C24: 1uF; C_0603_1608Metric
D_TVS, D_TVS9: SMF33A; SMF_L2.8-W1.8-LS3.7-RD
D_USB: RB160VAM-40; SOD-323HE_L2.0-W1.4-LS2.5-RD
FB_OSD: 600R@100MHz; L_0402_1005Metric
H1, H2, H3, H4: HOLE; MOUNT_M2_SLOT
J_ESC: Micro-Lock Plus 8P RA; CONN-SMD_8P-P1.25_5055670871
J_USB: USB-C; USB-C-SMD_MC-311D
LED_PWR: RED; LED0603-RD_1
LED_STAT: BLUE; LED0603-R-RD_BLUE
L_3V3: 0.47uH; IND-SMD_L2.5-W2.0_TFM252012ALMA2R2MTAA
L_5V, L_9V: 15uH; IND-SMD_L7.1-W6.5_SPM6530T
P_5V: PAD_SIG
P_BAT: PAD_MOTOR
P_BATG: PAD_MOTOR
P_CAM, P_CAM5V: PAD_SIG
P_CAMG: PAD_SIG
P_G1: PAD_SIG
P_HD9V: PAD_SIG
P_HDG: PAD_SIG
P_HDR: PAD_SIG
P_HDT: PAD_SIG
P_LED: PAD_SIG
P_R1, P_R2, P_R4: PAD_SIG
P_RX5V: PAD_SIG
P_RXG: PAD_SIG
P_T1, P_T2, P_T4: PAD_SIG
P_VTX, P_VTX9V: PAD_SIG
P_VTXG: PAD_SIG
Q_TSW: BSS138DW; SC-70-6_L2.0-W1.3-P0.65-LS2.1-BL
Q_VTX: AO3400A; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR
R1, R6, R8, R11, R14, R17, R18, R20: 100k; R_0402_1005Metric
R2, R31: 1k; R_0402_1005Metric
R3: 30k; R_0402_1005Metric
R4: 2k; R_0402_1005Metric
R5, R10: 57.6k; R_0402_1005Metric
R7, R9, R12: 24.9k; R_0402_1005Metric
R13: 100R; R_0402_1005Metric
R15: 121k; R_0402_1005Metric
R16, R24, R25, R26: 10k; R_0402_1005Metric
R19: 12.4k; R_0402_1005Metric
R21: 22.1k; R_0402_1005Metric
R22: 3.3k; R_0402_1005Metric
R23: 10R; R_0402_1005Metric
R27, R28: 75R; R_0402_1005Metric
R29, R30: 5.1k; R_0402_1005Metric
R32: 330R; R_0402_1005Metric
SW_BOOT: BOOT; SW-SMD_5P-L4.2-W2.8-P1.60-LS4.6-TR
TP_NRST: PAD_TP
TP_SWCLK: PAD_TP
TP_SWDIO: PAD_TP
U_BUCK3: TPS628501; SOT-583-8_L2.1-W1.6-P0.50-LS1.6-BL
U_BUCK5, U_BUCK9: LMR38020F; ESOP-8_L4.9-W3.9-P1.27-LS6.0-BL-EP-1
U_ESD: USBLC6-2SC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL
U_FC: STM32G473CEU6; UFQFPN-48_L7.0-W7.0-P0.50-BL-EP5.6
U_FLASH: S25FL128LAGNFM010; WSON-8_L6.0-W5.0-P1.27-BL-EP
U_IMU: IIM-42652; LGA-14_L3.0-W2.5-P0.50-TL
U_OSD: AT7456E; TSSOP-28_L9.7-W4.4-P0.65-LS6.4-BL-EP-2
U_TSW: TMP390A2; SOT-563_L1.6-W1.2-P0.50-LS1.6-BR
Y1: 8MHz; OSC-SMD_2P-L3.2-W2.5
Y2: 27MHz; CRYSTAL-SMD_4P-L3.2-W2.5-BL

Connections:
+3V3: C11.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C32.1, FB_OSD.1, J_ESC.4, L_3V3.2, R16.1, R17.1, R20.1, R23.1, R24.1, R25.1, R31.1, R32.1, SW_BOOT.2, SW_BOOT.3, U_FC.1, U_FC.20, U_FC.21, U_FC.23, U_FC.35, U_FC.48, U_FLASH.3, U_FLASH.7, U_FLASH.8, U_TSW.5
+3V3_GYRO: C29.1, C30.1, C31.1, R23.2, U_IMU.5, U_IMU.8
+3V3_OSD: C33.1, C34.1, C35.1, C36.1, FB_OSD.2, R26.1, U_OSD.3, U_OSD.21, U_OSD.24
+5V: C6.1, C7.1, C14.1, D_USB.1, L_5V.2, P_5V.1, P_CAM5V.1, P_RX5V.1, R8.1, U_BUCK3.1, U_BUCK3.2, U_BUCK3.3
+9V: C12.1, C13.1, L_9V.2, P_HD9V.1, P_VTX9V.1, R18.1
ADC_CURR: C1.1, R2.2, U_FC.18
ADC_VBAT: C2.1, R3.2, R4.1, U_FC.19
BOOT0: R22.1, SW_BOOT.1, SW_BOOT.4, U_FC.46
BUCK3_FB: C18.2, R20.2, R21.1, U_BUCK3.5
BUCK3_SW: L_3V3.1, U_BUCK3.7
BUCK5_CB: C5.1, U_BUCK5.7
BUCK5_EN: R6.2, R7.1, U_BUCK5.2
BUCK5_FB: R8.2, R9.1, U_BUCK5.5
BUCK5_RT: R5.1, U_BUCK5.4
BUCK5_SW: C5.2, L_5V.1, U_BUCK5.8
BUCK9_CB: C10.1, U_BUCK9.7
BUCK9_EN: Q_TSW.6, Q_VTX.3, R11.2, R12.1, U_BUCK9.2
BUCK9_FB: R18.2, R19.1, U_BUCK9.5
BUCK9_RT: R10.1, U_BUCK9.4
BUCK9_SW: C10.2, L_9V.1, U_BUCK9.8
CAM_VIDEO: C37.1, P_CAM.1, R27.1
CUR: J_ESC.3, R1.1, R2.1
FLASH_CS: R24.2, U_FC.29, U_FLASH.1
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, D_TVS.2, D_TVS9.2, J_ESC.2, J_USB.1, J_USB.2, J_USB.3, J_USB.4, J_USB.A1B12, J_USB.B1A12, LED_PWR.1, P_BATG.1, P_CAMG.1, P_G1.1, P_HDG.1, P_RXG.1, P_VTXG.1, Q_TSW.1, Q_TSW.4, Q_VTX.2, R1.2, R4.2, R5.2, R7.2, R9.2, R10.2, R12.2, R14.2, R15.2, R19.2, R21.2, R22.2, R27.2, R29.2, R30.2, SW_BOOT.5, U_BUCK3.4, U_BUCK3.8, U_BUCK5.1, U_BUCK5.9, U_BUCK9.1, U_BUCK9.9, U_ESD.2, U_FC.49, U_FLASH.4, U_FLASH.9, U_IMU.6, U_IMU.7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
GYRO_CS: U_FC.17, U_IMU.12
GYRO_INT: U_FC.12, U_IMU.4
HSE_IN: C27.1, U_FC.5, Y1.1
HSE_OUT: C28.1, U_FC.6, Y1.2
LED0: LED_STAT.2, U_FC.45
LED0_A: LED_STAT.1, R32.2
LED_PWR_A: LED_PWR.2, R31.2
LED_STRIP: P_LED.1, U_FC.44
M1_SIG: J_ESC.5, U_FC.8
M2_SIG: J_ESC.6, U_FC.9
M3_SIG: J_ESC.7, U_FC.10
M4_SIG: J_ESC.8, U_FC.11
NRST: C26.1, TP_NRST.1, U_FC.7
OSD_CS: R25.2, U_FC.30, U_OSD.8
OSD_RST: R26.2, U_OSD.19
OSD_VIN: C37.2, U_OSD.22
OSD_VOUT: R28.1, U_OSD.25, U_OSD.26
OSD_XI: U_OSD.5, Y2.1
OSD_XO: U_OSD.6, Y2.3
SPI1_MISO: U_FC.14, U_IMU.1
SPI1_MOSI: U_FC.15, U_IMU.14
SPI1_SCK: U_FC.13, U_IMU.13
SPI2_MISO: U_FC.27, U_FLASH.2, U_OSD.11
SPI2_MOSI: U_FC.28, U_FLASH.5, U_OSD.9
SPI2_SCK: U_FC.26, U_FLASH.6, U_OSD.10
SWCLK: TP_SWCLK.1, U_FC.37
SWDIO: TP_SWDIO.1, U_FC.36
UART1_RX: P_HDR.1, P_R1.1, U_FC.32
UART1_TX: P_HDT.1, P_T1.1, U_FC.31
UART2_RX: P_R2.1, U_FC.42
UART2_TX: P_T2.1, U_FC.41
UART4_RX: P_R4.1, U_FC.40
UART4_TX: P_T4.1, U_FC.39
USB_CC1: J_USB.A5, R29.1
USB_CC2: J_USB.B5, R30.1
USB_DM: J_USB.A7, J_USB.B7, U_ESD.3, U_ESD.4, U_FC.33
USB_DP: J_USB.A6, J_USB.B6, U_ESD.1, U_ESD.6, U_FC.34
USB_VBUS: D_USB.2, J_USB.A4B9, J_USB.B4A9, U_ESD.5
VBAT: C3.1, C4.1, D_TVS.1, J_ESC.1, R3.1, R6.1, U_BUCK5.3
VBAT_VTX: C8.1, C9.1, D_TVS9.1, P_BAT.1, R11.1, U_BUCK9.3
VTX_COOL: Q_TSW.5, R16.2, U_TSW.6
VTX_HOT_G: Q_TSW.2, Q_TSW.3, R17.2
VTX_OFF: R13.1, U_FC.43
VTX_OFF_G: Q_VTX.1, R13.2, R14.1
VTX_TSET: R15.1, U_TSW.1
VTX_VIDEO: P_VTX.1, R28.2

## Code that names these connections

File canary/v1/firmware/src/board.h:

/* Canary v1 pin map. check_pins.py compares this file with
 * src/circuit.py (FIRMWARE_PINS) and the schematic netlist. */
#ifndef BOARD_H
#define BOARD_H

#define F_CPU_HZ        8000000UL   /* internal RC, CKDIV8 off (lfuse 0xE2) */

/* pin: NET  PORT BIT */
#define PIN_LED_GRN     PD3     /* LED_GRN   OC2B */
#define PIN_LED_AMB     PD5     /* LED_AMB   OC0B */
#define PIN_LED_RED     PD6     /* LED_RED   OC0A */
#define PIN_BUZ         PB1     /* BUZ       OC1A */
#define PIN_BTN         PD2     /* BTN       INT0 */
#define PIN_SDA         PC4     /* SDA       TWI  */
#define PIN_SCL         PC5     /* SCL       TWI  */
#define PIN_NTC_BRD     PC0     /* NTC_BRD   ADC0 */
#define PIN_NTC_PRB     PC1     /* NTC_PRB_F ADC1 */
#define PIN_TXD         PD1     /* TXD       USART */
#define PIN_RXD         PD0     /* RXD       USART */

#define ADC_CH_NTC_BRD  0
#define ADC_CH_NTC_PRB  1

/* NTCs: on-board Murata NCU18XH103F60RB (10k, B25/50 3380 K) on the
 * thermal tab; optional probe: any 10k B3950 NTC on the JST-PH. Both are
 * the low side of a divider with a 10k 0.1 % resistor from 3V3. */
#define NTC_R25         10000.0f
#define NTC_B_BRD       3380.0f
#define NTC_B_PRB       3950.0f

#define BUZ_HZ          4000    /* CMT-8504 resonance */

#define I2C_SGP40       0x59
#define I2C_SHT40       0x44
#define I2C_SCD41       0x62

#endif

File layercam-pro/v1/firmware/pincheck.py (part):

"""The camera software's pins against the schematic, as (ok, description) pairs.

src/circuit.py is the source of truth: main_soc() names each SoC pin's net
and, in its comment, the pin's function (GPIO1_A0, SARADC_IN1, PWM3_IR_M1,
I2C4_SCL_M2...).  This reads that file as text (no import, nothing
installed: it runs in the board build's Python too) and checks
layercam/board.py and dts/rv1106g-layercam-pro-v1.dts against it.

Used by tests/test_pins.py and by the board build (src/verify.py through
src/check_firmware.py).  Standard library only.
"""
import os, re, sys
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    # board.py's GPIOs are the ones circuit.py names
    for net, gpio in sorted(board.PINS.items()):
        if net == 'IR_PWM':
            item('PWM3_IR_M1' in pins.get(net, ''), 'firmware IR_PWM on PWM3_IR_M1 (circuit.py: %s)' % pins.get(net))
            continue
        item(comment_gpio(net) == gpio, 'firmware %s on %s (circuit.py: %s)' % (net, gpio, comment_gpio(net)))

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        b, p = gpio_ref(board.PINS[net])
        return r'<&gpio%s %s ' % (b, p)

    has(r'status_led: status \{[^}]*gpios = ' + re.escape(gref('LED_STATUS')), 'status LED on LED_STATUS')
    # Wi-Fi: the ESP32-C6 (esp-hosted) on SDMMC0
    has(r'sdio-pwrseq \{[^}]*reset-gpios = ' + re.escape(gref('WIFI_EN')) + 'GPIO_ACTIVE_LOW',
        'WIFI_EN (the C6\'s EN) drives the SDIO power sequence')
    has(r'sdio-pwrseq \{[^}]*post-power-on-delay-ms = <1500>;', 'the C6 gets 1500 ms after EN (esp-hosted)')
    has(r'&sdmmc \{[^}]*mmc-pwrseq = <&sdio_pwrseq>;[^}]*espressif,full-chip-reset;',
        'SDMMC0 uses the power sequence, marked as a full C6 reset')
    b, p = gpio_ref(board.PINS['WIFI_BOOT'])
    has(r'<%s %s RK_FUNC_GPIO &pcfg_pull_up>' % (b, p), 'WIFI_BOOT (the C6\'s GPIO9) a GPIO pulled up')
    has(r'pinctrl-0 = <&ircut_pins &wifi_boot &wifi_host_wake>;', 'WIFI_BOOT and WIFI_HOST_WAKE pins set at boot')
    b, p = gpio_ref(board.PINS['WIFI_HOST_WAKE'])
    has(r'<%s %s RK_FUNC_GPIO &pcfg_pull_down>' % (b, p), 'WIFI_HOST_WAKE an input, pulled down')
    item(not re.search(r'wlan-platdata|bluetooth-platdata|wifi_chip_type', dts_text),
         'device tree: no bcmdhd or Bluetooth platform nodes')
    item('UART1_TX_M0' in pins.get('WIFI_RXD', '') and 'UART1_RX_M0' in pins.get('WIFI_TXD', ''),
         'circuit.py: the C6\'s UART0 on UART1_M0')
    has(r'&uart1 \{[^}]*pinctrl-0 = <&uart1m0_xfer>;[^}]*status = "okay"', 'UART1 on its M0 pins, TX/RX only')
    item(board.WIFI_UART == '/dev/ttyS1', 'firmware flashes the C6 on /dev/ttyS1 (serial1 = UART1)')
    item(re.search(r"'8': 'WIFI_EN'", circuit_text) and re.search(r"'23': 'WIFI_BOOT'", circuit_text),
         'circuit.py: WIFI_EN to the C6\'s EN (pin 8), WIFI_BOOT to its IO9 (pin 23)')
    # camera: the SC4336H, XSHUTDN = reset-gpios, PWDNB = pwdn-gpios
    sensor = r'%s@%x \{[^}]*' % (board.SENSOR, board.SENSOR_I2C_ADDR)
    has(sensor + r'compatible = "smartsens,%s";' % board.SENSOR, 'sensor node %s, compatible smartsens,%s'
        % (board.SENSOR, board.SENSOR))
    has(sensor + r'reg = <0x%x>;' % board.SENSOR_I2C_ADDR, 'sensor at I2C 0x%x' % board.SENSOR_I2C_ADDR)
    has(sensor + r'reset-gpios = ' + re.escape(gref('CAM_RST')), 'CAM_RST is the sensor\'s reset (XSHUTDN)')
    has(sensor + r'pwdn-gpios = ' + re.escape(gref('CAM_PWDN')), 'CAM_PWDN is the sensor\'s pwdn (PWDNB)')
    has(sensor + r'rockchip,camera-module-name = "%s";[^}]*rockchip,camera-module-lens-name = "%s";'
        % (board.SENSOR_MODULE, board.SENSOR_LENS), 'module and lens names pick %s' % board.IQ_FILE)
    has(r'%s_out: endpoint \{[^}]*data-lanes = <1 2>;' % board.SENSOR, 'sensor on 2 MIPI lanes')
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        b, p = gpio_ref(board.PINS[net])
        has(r'<%s %s RK_FUNC_GPIO &pcfg_pull_down>' % (b, p), '%s held low as a GPIO' % net)
    has(r'&pwm3 \{[^}]*pinctrl-0 = <&pwm3m1_pins>', 'PWM3 on its M1 pin')
    mclk = pins.get('CAM_MCLK_SOC', '')
    item('MIPI_CLK0_OUT' in mclk and 'GPIO3_C4' in mclk, 'circuit.py: sensor clock on MIPI_CLK0_OUT (GPIO3_C4)')
    has(r'pinctrl-0 = <&mipi_refclk_out0>', 'sensor clock on mipi_refclk_out0')
    item('I2C4_SCL_M2' in pins.get('CAM_SCL', '') and 'I2C4_SDA_M2' in pins.get('CAM_SDA', ''),
         'circuit.py: camera I2C on I2C4_M2')
    has(r'&i2c4 \{[^}]*pinctrl-0 = <&i2c4m2_xfer>', 'I2C4 on its M2 pins')
    item('SARADC_IN%d' % board.ADC_LIGHT in pins.get('ALS', ''),
         'light sensor on SARADC channel %d (circuit.py: %s)' % (board.ADC_LIGHT, pins.get('ALS')))
    item('SARADC_IN%d' % board.ADC_BOOT_PAD in pins.get('BOOT_KEY', ''),
         'BOOT pad on SARADC channel %d (circuit.py: %s)' % (board.ADC_BOOT_PAD, pins.get('BOOT_KEY')))
    has(r'&saradc \{[^}]*status = "okay"', 'SARADC enabled')
    # no button: the firmware relies on none, and the evb's ADC keys must not claim the BOOT pad
    item(not re.search(r"add\('SW'", circuit_text), 'circuit.py: no button (the firmware needs none)')
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
File layercam-pro/v1/firmware/layercam/board.py:

"""The board's pins as Linux sees them.

Every value here comes from src/circuit.py's main_soc() pin map (the comment
on each pin names its function) and is checked against it, and against the
device tree in dts/, by tests/test_pins.py.  Rockchip numbers a GPIO
bank * 32 + group * 8 + index, groups A-D = 0-3: GPIO1_A0 = 32.
"""

def gpio_number(name):
    """'GPIO1_A0' -> 32."""
    bank, pin = name[4:].split('_')
    return int(bank) * 32 + 'ABCD'.index(pin[0]) * 8 + int(pin[1:])

# nets of circuit.py and the SoC pin they are on
PINS = {
    'IRCUT_A': 'GPIO1_A0',       # DRV8837 IN1
    'IRCUT_B': 'GPIO1_A1',       # DRV8837 IN2
    'WIFI_EN': 'GPIO1_A2',       # ESP32-C6 EN (mmc-pwrseq in the device tree)
    'WIFI_BOOT': 'GPIO0_A2',     # ESP32-C6 GPIO9 strap: low at EN rise = UART download (tools/layercam-c6-flash.py)
    'WIFI_HOST_WAKE': 'GPIO0_A3',  # ESP32-C6 IO4, esp-hosted's host wake (wired, unused)
    'LED_STATUS': 'GPIO1_C0',
    'CAM_RST': 'GPIO3_C5',       # SC4336H XSHUTDN (reset-gpios)
    'CAM_PWDN': 'GPIO3_C6',      # SC4336H PWDNB (pwdn-gpios)
    'IR_PWM': 'GPIO1_B0',        # PWM3_IR_M1
}

IRCUT_A = gpio_number(PINS['IRCUT_A'])
IRCUT_B = gpio_number(PINS['IRCUT_B'])
WIFI_EN = gpio_number(PINS['WIFI_EN'])
WIFI_BOOT = gpio_number(PINS['WIFI_BOOT'])

# the Wi-Fi module's UART0, for flashing it from Linux: UART1_M0 (serial1)
WIFI_UART = '/dev/ttyS1'

# SARADC channels (in_voltageN_raw)
ADC_BOOT_PAD = 0                 # SARADC_IN0: the BOOT pad (TP5), MaskROM strap; 10k up to 1.8 V. Read for diagnostics only
ADC_LIGHT = 1                    # SARADC_IN1, TEMT6000 across 22k: ~0.5 V at 50 lux
ADC_DEVICE = '/sys/bus/iio/devices/iio:device0'

# PWM3 (ff350030) on its M1 pin; the device tree names the controller, the
# pwmchip number depends on probe order, so it is found by address.
PWM_IR_GLOB = '/sys/devices/platform/ff350030.pwm/pwm/pwmchip*'
PWM_IR_PERIOD_NS = 1000000       # 1 kHz: the AO3400A's gate (100R, 100k) switches cleanly

# the status LED is a gpio-leds node in the device tree
LED_STATUS = '/sys/class/leds/status'

# the IR-cut coil: 3.3 V for 100-500 ms (Commonlands), then the bridge off
IRCUT_PULSE_S = 0.2

# sensor: SmartSens SC4336H, bare on the board, 2-lane MIPI, 24 MHz clock.
# 2560 x 1440 is the SC4336 family's mode (the SDK's sc4336.c; SmartSens'
# SC4336H flyer: 2560x1440 at 30 fps).  The driver is a port of sc4336.c
# (tools/sc4336h-port.py); its name and the IQ file follow from these.
SENSOR = 'sc4336h'
SENSOR_WIDTH, SENSOR_HEIGHT = 2560, 1440
SENSOR_I2C_BUS, SENSOR_I2C_ADDR = 4, 0x30
SENSOR_CHIP_ID_REG = 0x3107      # 16 bits, 0x3107/0x3108, as the whole SC3336/SC4336 family
# rockchip,camera-module-name / -lens-name in the device tree: rkaiq loads
# /etc/iqfiles/<sensor>_<module>_<lens>.json
SENSOR_MODULE, SENSOR_LENS = 'LayerCamPro', 'LCP-F16'
IQ_FILE = '%s_%s_%s.json' % (SENSOR, SENSOR_MODULE, SENSOR_LENS)

File products/mesh-radio/sim/rf/rfboard.py (part):

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                     ('LORA_TX50', _between('LORA_TXC', 'LORA_TX50')[0]), ('PA_M1', DCBLOCK_OUT), ('PA_M2', DCBLOCK_OUT),
                     ('PA_M3', _between('PA_M2', 'PA_M3', 'L')[0]), ('BLE_50R', _between('NRF_ANT', 'BLE_50R')[0])):
        P[net] = '%s.%s' % (ref, _pin_on(ref, net)[0])
    rx = [c.ref for c in COMPS if 'RX_SW' in c.pins.values() and c.ref != sw][0]
    P['RX_SW'] = '%s.%s' % (rx, _pin_on(rx, 'RX_SW')[0])
    return P

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    dv = np.array(p0) - pf
    perp = abs(float(u[0] * dv[1] - u[1] * dv[0]))
    esd = [c_ for c_ in rf_parts(NETS_ANT)][0].ref
    ke = a['pads']['%s.%s' % (esd, _pin_on(esd, 'ANT')[0])]
    stub = [e for e in a['edges'] if ke in (e['a'], e['b'])][0]
    kj = stub['b'] if stub['a'] == ke else stub['a']
    trim = lambda k: sum(e['len'] - e['len_out'] for e in a['edges'] if k in (e['a'], e['b']) and e is not stub)
    term = [x for x in rf_parts(['REFL_CPL']) if parts.PARTS[x.part]['kind'] == 'R']
    t_flt = [x.ref for x in term if 'U.FL end' not in x.note][0]
    t_ufl = [x.ref for x in term if 'U.FL end' in x.note]
    pk = lambda ref: c['pads']['%s.%s' % (ref, _pin_on(ref, 'REFL_CPL')[0])]
    g = dict(cpl_len=run['len'], gap=round(perp - run['w'], 4), flt_cpl=s(p0) - trim(kf), cpl_ufl=s(pu) - s(p1) - trim(ku),
             esd_from_end=s(p1) - s(na[kj]), esd_stub=stub['len_out'], stub_term=_path('REFL_CPL', kc0, pk(t_flt)))
    g['term_fwd'] = _path('REFL_CPL', pk(t_flt), pk(DIODE_FWD.ref)) if DIODE_FWD is not None else 0.0
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
def _det_diode(net):
    for c in COMPS:
        if parts.PARTS[c.part]['kind'] == 'D' and net in c.pins.values() and 'REFL_CPL' in c.pins.values():
            return c
    return None

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
def _filter_ref():
    for c in COMPS:
        if parts.PARTS[c.part]['kind'] == 'FL' and 'ANT_SW' in c.pins.values():
            return c
    raise KeyError('no antenna filter on ANT_SW')

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_flp = parts.PARTS[FL_PART]['symbol']['pins']
FL_IN = [p for p, (n, t) in _flp.items() if n == 'RF IN'][0]
FL_OUT = [p for p, (n, t) in _flp.items() if n == 'RF OUT'][0]
assert FL.pins[FL_IN] == 'ANT_SW' and FL.pins[FL_OUT] == 'ANT', 'antenna filter orientation changed in circuit.py'
FL_NAME = parts.PARTS[FL_PART]['mpn']

# QPA9510 internal model (ASSUMED; README): bond wires from the die to the RF OUT pins,
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    return [c.ref for c in COMPS if pred(c)]

PAD_REFS = _refs(lambda c: parts.PARTS[c.part]['kind'] == 'R' and set(c.pins.values()) <= {'LORA_TX50', 'PA_DRIVE', 'GND'})
DCBLOCK_PA = _refs(lambda c: set(c.pins.values()) == {'PA_DRIVE', 'PA_RFIN'})[0]
DCBLOCK_OUT = _refs(lambda c: set(c.pins.values()) == {'PA_M1', 'PA_M2'})[0]

def rf_parts(nets):
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        return c

    def pa_out(self, c):
        """QPA9510 output: die (current source node DIE) -> bond wires -> PA_OUT pins and
        the external match, choke and 2F0 trap from circuit.py."""
        pins = _pin_on(PA_REF, 'PA_OUT')
        if self.route(c, 'PA_OUT'):          # routed: a bond wire to each RF OUT pin's pad, together PA_LBOND
            for p_ in pins:
                c.add('DIE', pad_node('PA_OUT', PA_REF, p_), R.Ind(PA_LBOND * len(pins), 40, 1e9, 0, 0.005 * len(pins)),
                      'PA_bond' + p_)
        else:
            c.add('DIE', 'PA_OUT', R.Ind(PA_LBOND, 40, 1e9, 0, 0.005), 'PA_bond')
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    def _sw_ant_line(self, c, L):
        """Switch RF1 (SW1) to the filter's RF IN (ANT_SW): the routed ANT_SW net (plus sw_lfcn), or a line."""
        if self.routed and self.route(c, 'ANT_SW'):
            _tie(c, 'SW1', pad_node('ANT_SW', SW_REF, _pin_on(SW_REF, 'ANT_SW')[0]), L['sw_lfcn'], 'line_sw_lfcn')
        else:
            c.add2('SW1', 'ANT_SW', R.Line(L['sw_lfcn']), 'line_sw_lfcn')

    def _sw_rx_line(self, c, L):
        if self.routed and self.route(c, 'RX_SW'):
            _tie(c, 'SW3', pad_node('RX_SW', SW_REF, _pin_on(SW_REF, 'RX_SW')[0]), L['sw_rx'], 'line_sw_rx')
        else:
            c.add2('SW3', 'RX_SW', R.Line(L['sw_rx']), 'line_sw_rx')

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
File print-hub/v1/firmware/src/board.h:

// Print Hub v1: the pins and the hardware behind lib/hub's Hal.
//
// The pin numbers are ESP32-S3 GPIOs and must match the board
// (src/circuit.py): src/verify.py reads this file and checks every one.
#pragma once
#include <Adafruit_NeoPixel.h>
#include <Arduino.h>
#include <Wire.h>

#include "hub.h"

namespace pins {
// per port, USB1..USB5
constexpr uint8_t EN[hub::NPORTS] = {21, 10, 11, 12, 13};     // power switch enable, high = on
constexpr uint8_t FLT[hub::NPORTS] = {14, 15, 16, 17, 18};    // power switch fault, low = fault
constexpr uint8_t ISENSE[hub::NPORTS] = {1, 2, 4, 5, 6};      // current-sense amplifier out (ADC1)
constexpr uint8_t VIN_SENSE = 7;    // POWER IN voltage through a divider (ADC1)
constexpr uint8_t RAIL_SENSE = 8;   // the 5 V port rail through a divider (ADC1)
constexpr uint8_t NTC = 9;          // board temperature: NTC to ground, 10k up to 3.3 V (ADC1)
constexpr uint8_t LED_DATA = 38;    // WS2812B chain: status, then USB5 ... USB1
constexpr uint8_t I2C_SDA = 39;     // USB-PD sink controller
constexpr uint8_t I2C_SCL = 40;
constexpr uint8_t BUTTON = 0;       // BOOT button, low = pressed
}  // namespace pins

// the analogue scaling, from src/circuit.py's parts
namespace scale {
// current sense: shunt (ohm) x amplifier gain (V/V) -> volts per amp
constexpr float SHUNT_OHM = 0.020f;
constexpr float AMP_GAIN = 50.0f;
constexpr float MV_PER_MA = SHUNT_OHM * AMP_GAIN;   // 1.0 mV per mA
// dividers: (top + bottom) / bottom
constexpr float VIN_DIV = (100.0f + 15.0f) / 15.0f;
constexpr float RAIL_DIV = (100.0f + 100.0f) / 100.0f;
// board temperature: Murata NCP15XH103F03RC (10k at 25 C) under a 10k
// pull-up from the 3.3 V rail.  B25/85 = 3434 K: the curve is fitted where
// the thermal protection acts (74-80 C); at 25 C it reads ~0.3 K low
constexpr float NTC_R0_OHM = 10000.0f;
constexpr float NTC_B = 3434.0f;
constexpr float NTC_PULLUP_OHM = 10000.0f;
constexpr float NTC_SUPPLY_MV = 3300.0f;
}  // namespace scale

class Board : public hub::Hal {
 public:
  void begin();
  void poll(uint32_t now);
  void set_enable(int port, bool on) override;
  bool fault(int port) override;
  uint16_t port_ma(int port) override { return ma_[port]; }
  uint16_t input_budget_ma() override;
  int16_t board_temp_c10() override { return temp_c10_; }
  uint16_t input_mv() const { return vin_mv_; }
  uint16_t rail_mv() const { return rail_mv_; }
  std::string contract() const { return contract_; }
  void set_led(int i, uint32_t rgb) { leds_.setPixelColor(i, rgb); }
  void show_leds() { leds_.show(); }
  bool button_pressed();

 private:
  void read_pd();
  void read_ntc();
  Adafruit_NeoPixel leds_{hub::NPORTS + 1, pins::LED_DATA, NEO_GRB + NEO_KHZ800};
  uint16_t ma_[hub::NPORTS] = {};
  uint16_t vin_mv_ = 0, rail_mv_ = 0;
  uint16_t pd_mv_ = 0, pd_ma_ = 0;   // the charger's contract: volts and amps it offers
  std::string contract_ = "none";
  uint32_t pd_at_ = 0;
  int16_t temp_c10_ = hub::NO_TEMP;  // tenths of a degree C, NO_TEMP: open or shorted
  uint32_t ntc_at_ = 0;
  bool asked_ = false;               // asked for the 9 V offer since plug-in
  bool button_was_ = false;
  uint32_t button_at_ = 0;
};

File products/mesh-radio/sim/board.py (part):

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  cell -- leads -- JST -- CSD25310Q2 -- BAT_P --TPS22950--RB060MM-- VSYS -- TPS62840 (EN = switch) -- 3V3
     (gate: off unless the SSM3K56ACT polarity check sees the cell the right way round;
      - side: BQ29700 + SSM10N954L + 22 mOhm to GND)
  BAT_P --IN1-- TPS2121 --IN2-- VSYS   (PR1 562 k / 374 k; a GPIO FET can pull PR1 low)
                  OUT = PA_IN -- TPS63810 -- VPA (2 x 47 uF 1206 X7S) -- QPA9510

PCB parasitics (TRACE_*, SENSE_TRACE) are extracted from the routed board
(../mesh-radio.kicad_pcb, 3 Nov 2026) by extract.py, which prints them next
to the pre-routing estimates; re-run it after any change to the copper and
copy its values here.  The simulation's BAT_P node is the reverse FET's
source pins (Q1), its VSYS node the charger's SYS pins (U4).  Track
resistance follows copper's +0.393 %/C from 25 C (build()).
"""
import powerlib as P
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TRACE_SOLAR = (0.0018, 0.8e-9)  # (5, 5 in hotplug): solar JST -> MAX17608 IN + GND charger -> JST
TRACE_DRONE = (0.0356, 7.4e-9) # (5, 5 in hotplug): drone JST-GH -> MAX17608 IN + GND charger -> JST-GH
# in the BQ29700's sense loop, in series with the 15 mOhm sense resistor (V- through
# 2.2 k to GND at R33, VSS on CELL_MINUS at U5): since 5 Nov the FETs' source pins
# run straight into R34 beside them on B.Cu, 0.6 mm wide and poured (until then
# 18.1 mOhm: PROT_S2 dropped to In1 for 5 mm, 16.9 mOhm of it)
SENSE_TRACE = 0.0004            # (none: the README asked for it to be added here)
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    ns['CHok'] = 1 if c['usb'] else 0
    if c['usb']:
        u = c['usb']
        ns.update(FUramp=u, USB_VBUS=u, usb_conn=u, USB_5V=u - 0.05, VIN_USB=u - 0.45, VIN_CHG=u - 0.45, FUuv=1, FUuvp=1, FUovl=0,
                  FUtov=0)
    ns.update(c.get('nodeset', {}))
    # nodes that only a board trace separates from their parent start where it does (a study's
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
File products/mesh-radio/src/board.py (part):

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    # alone (5 Nov, three re-routes).  Straight up beside the RFO escape at
    # the RF gap, then across to the choke's VR_PA pad above the line.
    sxr = [c.ref for c in comps if c.part == 'SX1262']
    chk = [c.ref for c in comps if set(c.pins.values()) == {'LORA_VRPA', 'LORA_RFO'}]
    if sxr and chk:
        mm_ = lambda p: (p.GetPosition().x / 1e6 - pcb.CX, p.GetPosition().y / 1e6 - pcb.CY)
        sxf = b.FindFootprintByReference(sxr[0]); lf = b.FindFootprintByReference(chk[0])
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        sp = [mm_(p) for p in f.Pads() if p.GetNetname() == 'PROT_S2']
        # each row's pin nearest the shunt (its neighbour joins it, join_pads):
        # from the other one the 0.6 mm track's end came 0.035 mm from the
        # row's CELL_MINUS pin, a clearance error (3 Nov)
        rows = {}
        for q in sp:
            rows.setdefault(round(q[1], 2), []).append(q)
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