# Repository offgridevices/offgrid-hardware

File README.md:

# offgrid-hardware

Open hardware from [OffGrid Devices](https://github.com/offgridevices). Every
product is one folder in [`products/`](products/), changed in place from one
revision to the next; variants of one line share a family folder.

```
products/
  canary/                   Canary
  layercam/                 LayerCam family (README: how the variants differ)
    layercam/               LayerCam
    layercam-pro/           LayerCam Pro
  mesh-radio/               Mesh Radio
  packet-logger-carrier/    Packet Logger Carrier
  print-hub/                Print Hub
  ridge/                    Ridge family (README: how the variants differ)
    ridge-3/                Ridge 3
    ridge-3-lite/           Ridge 3 Lite
  smokebreak/               SmokeBreak
docs/                       how we build boards
tools/ci/                   CI helpers shared by every product
```

| Product | Revision | What it is | Status |
|---|---|---|---|
| [Canary](products/canary/) | v1 | 60 × 40 mm first-vent detector for lithium batteries charging at home — VOC + CO₂ + heat fusion, 100 dB sounder, USB-C | designed and simulation-verified, not yet built |
| [LayerCam](products/layercam/layercam/) | v1 | A camera for the inside of a Prusa CORE One, in Prusa's own Buddy3D case — RV1106 Linux SoC, 1080p wide angle with IR night vision, Prusa Connect, per-layer timelapse to a NAS or S3; three boards, 6 layers for the main one | designed, not yet built |
| [LayerCam Pro](products/layercam/layercam-pro/) | v1 | LayerCam's camera on **one** 6-layer board in the same Buddy3D case — SC4336H sensor soldered on, ESP32-C6 Wi-Fi with an external antenna, no board-to-board cables, rated for a 65 °C chamber | designed, not yet built |
| [Mesh Radio](products/mesh-radio/) | 1.0 | 70 × 25.4 mm LoRa + Bluetooth mesh radio, up to 3 W (SX1262 + QPA9510, nRF52840), 6 layers, from parts a US or allied factory can build | routed and simulated, not yet built |
| [Packet Logger Carrier](products/packet-logger-carrier/) | v1 | 86 × 58 mm carrier for a LoRa mesh packet logger — RAK19003 + XIAO ESP32-C6 + microSD | ordered, not yet bench-verified |
| [Print Hub](products/print-hub/) | v1 | 86 × 50 mm, five switched USB ports for a resin printer's accessories, ESP32-S3 on Wi-Fi and USB, USB-PD in, printed enclosure | designed, not yet built |
| [Ridge 3](products/ridge/ridge-3/) | 2.0 | A 36 × 36 mm flight controller with HD or analog video and a separate 4-in-1 ESC on a machined heatsink, for 3" FPV quads | designed and simulated, not yet ordered |
| [Ridge 3 Lite](products/ridge/ridge-3-lite/) | v1 | 38 × 38 mm flight controller + 4-in-1 ESC for a 3" quad, 8 layers | designed, not yet built |
| [SmokeBreak](products/smokebreak/) | v1 | Handheld smoke stopper and LiPo checker, 2S–14S, 2.25" screen, printed case | designed, not yet built |

The packet logger's firmware and analysis tooling live in
[`mesh-fieldlab`](https://github.com/offgridevices/mesh-fieldlab); every other
product's firmware is in its own folder.

Ridge 3 and Ridge 3 Lite are separate designs for 3-inch quads and share no
files: Ridge 3 is a two-board stack (a flight controller with video, and an
ESC on a heatsink), Ridge 3 Lite one board that carries both
([`products/ridge/`](products/ridge/)).

To make a board's product video, an exploded view rendered from its KiCad
file, follow [`docs/product-video.md`](docs/product-video.md).

---

## How to order one

To get a board made, you need its **Gerber zip** (upload it to the fab) and its **BOM / CPL** (what to
buy, or what the fab assembles). The board's own `README.md` says where they
are, which fab settings to pick, and how to bring the board up. Start there.

You do **not** need KiCad, Python, or any of this repository's tooling to
order a board. The manufacturing files are committed, ready to upload.

## How to change one

The design files are the **scripts in each board's `src/`**, not the
Gerbers. Nobody modifies a board by hand-editing Gerbers, so the scripts are
what this project publishes as its source — in the words of the open hardware
definition, the preferred format for making modifications.

Each board is generated by its scripts, with verification gates that fail
the build rather than warn. Its README gives the one command that rebuilds
everything (some boards run it inside a pinned KiCad container).

Generated outputs are committed alongside the scripts that produce them, so a
stranger can order a board without a toolchain. They are expected to agree:
a script change without regenerated outputs is a defect, not untidiness. CI
rebuilds each board whose folder changed and checks that. Where routing was finished by hand,
the routed board file is the design of record: CI rebuilds everything after
the routing (artwork and fab files) and checks those, and the board's README
says so.

## Revisions

A product's folder always holds its latest revision. The revision is a
number in the product's code, printed on the board and listed in its
README's Revisions table. When a revision is ordered, the commit its files
came from gets a tag (`print-hub-rev1.0`) and a GitHub Release with the
exact Gerber zip, BOM and CPL that were ordered; a later change to the
board bumps the number. To get an ordered revision, download its release
or `git checkout` its tag. The rules are in
[`docs/versioning.md`](docs/versioning.md).

## Building a new board

Read [`docs/`](docs/) first: the workflow and what "done" means, the folder
layout and size budget, the brand rules, and lessons from earlier boards. A
new product gets its own folder in `products/`, and its own CI job by
adding `tools/ci.sh`, `tools/ci-setup.sh` and `tools/ci.json`
([`docs/repo-structure.md`](docs/repo-structure.md#ci)).

---

## Licence

**[CERN-OHL-S v2](LICENSE)** — the strongly reciprocal CERN Open Hardware
Licence. Use it, build it, sell it, modify it. If you distribute a modified
board, publish your design files under the same terms.

Copyright © OffGrid Devices.

A note on why this differs from `mesh-fieldlab`, which is GPL-3.0: that
licence is inherited from the Meshtastic libraries the firmware and tooling
depend on. A PCB has no such dependency, and GPL's language — source code,
object code, installation information — does not map cleanly onto Gerbers and
drill files. CERN-OHL-S is written for hardware and carries the same
reciprocal intent.

## KiCad design canary/v1/canary.kicad_pcb

File canary/v1/README.md (part):

# Canary v1 — first-vent detector for lithium batteries

**Status: designed and verified in simulation, not yet built.** Every gate below
passes on this revision; no board has been assembled or powered yet.

## What it is

A 60 × 40 mm board you put next to (or on) an e-bike or scooter battery
while it charges. It watches for the **first vent** — the moment a failing
cell boils off electrolyte as solvent vapour and CO₂ — which comes *before*
self-heating, thermal runaway and smoke. A smoke alarm reacts at the end of
that chain; Canary is built to react near its start.

Grid storage and EV packs already carry off-gas detectors (Honeywell BES,
Li-ion Tamer). The battery charging in a hallway has nothing. Canary is that
detector as an open, cheap, USB-powered board you can order fully assembled.

It fuses three kinds of evidence and needs **two at once** to alarm:

| Evidence | Sensor | Fires on | Alone it means |
|---|---|---|---|
| Gas | Sensirion **SGP40** MOX (on the isolated sensor head) | raw signal ≥ 700 ticks below its learned clean-air baseline (strong ≥ 2500) | WARN (cleaning spray, solvents) |
| CO₂ | Sensirion **SCD41** photoacoustic | rise ≥ 250 ppm/min or ≥ 1500 ppm over baseline (strong ≥ 1200 ppm/min or ≥ 4000 ppm) | WARN (someone breathing on it) |
| Heat | NTC on the **thermal tab** (or remote probe) | ≥ 50 °C, or ≥ 1 °C/min above 35 °C (strong: ≥ 65 °C, or ≥ 3 °C/min above 30 °C) | WARN; strong heat alone → ALARM |

ALARM = gas **and** CO₂ (one strong), or heat **and** any gas evidence, or
strong heat alone; held 3 s before it sounds, latched for at least 60 s.
Outputs: green breathing (watching), amber (one kind of evidence), red
flashing + 100 dB 4 kHz sounder in the smoke-alarm T3 pattern. The button
self-tests in normal state and hushes for 2 minutes in alarm — the hush
ends early if the evidence gets worse.

**Product video:** a narrated 4-minute explainer, built by `video/` and
published rather than committed ([video/README.md](video/README.md)).

The real firmware, on a simulated ATmega328P with virtual sensors, catching
a vent at 400 s (alarm 7.6 s later) — `sim/hil/`:

## Requirements, and whether they are met

| Requirement | How it is checked | Met? |
|---|---|---|
| Order from PCBWay, arrive assembled and working | Gerbers + PCBWay BOM + CPL + firmware HEX in `production/`; all parts on top; every part has an MPN | Yes (files); hardware not yet built |
| Parts in production today | Distributor check 2026-10-14, [docs/sourcing-2026-10-14.md](docs/sourcing-2026-10-14.md) | Yes — one NRND part replaced (NTC) |
| Latest KiCad | KiCad **10.0.6** (`kicad/kicad:10.0.6-full`), current stable | Yes |
| Schematic clean | `kicad-cli sch erc`: **0 violations** | Yes |
| Board clean, fab's limits | `kicad-cli pcb drc --schematic-parity --severity-all`: **0 errors, 0 warnings, 0 unconnected** against PCBWay 2-layer limits (with margin) | Yes |
| Clean copper, wide enough for its current | `check_geometry.py`: no corner sharper than 45° (the router's six right angles mitered by `miter.py`); every power track ≥ 2.4× its IPC-2221 width at a 10 °C rise | Yes |
| Schematic = circuit = board = firmware | `check_netlist.py` (27 nets, 0 mismatches), DRC parity, `check_pins.py` (11 pins, 0 mismatches) | Yes |
| Detects a vent within seconds, ignores single-cause events | HIL simulation of the real firmware: vent → ALARM in **7.6 s**; spray, breath → no alarm; still detecting after 100 min of charging; **65/65 checks** across 9 scenarios | Yes, in simulation |
| Sounder driver safe | ngspice: drain clamped at **5.4 V** on 5 V, clamp diode ≤ 0.34 A, VBUS dip ≥ 4.95 V, for 0.5–4 mH coils | Yes |
| Pack temperature good enough at the thresholds | Tolerance stack-up: ≤ 1.24 °C worst case at 65 °C; rate quantum 0.2 °C/min | Yes |
| Runs from any USB charger | 23.5 mA watching, ~520 mA worst-case peak in alarm | Yes (≤ 900 mA) |

## How to order (PCBWay, fully assembled)

1. **PCB**: upload `production/canary-gerbers.zip`.
   - 2 layers, FR-4, **1.6 mm**, 60 × 40 mm, 1 design
   - Min track/spacing **6/6 mil** (the design's tightest gap is 0.2 mm), min hole **0.3 mm**
   - Solder mask **yellow**, silkscreen **black** (white is fine if black is not offered on yellow)
   - Surface finish **ENIG** (fine-pitch DFN sensors)
   - The board has three internal routed slots (1.0 mm wide): they are intended, not errors.
2. **Assembly**: turnkey, **top side only**, 43 placements / 27 unique parts.
   - BOM: `production/canary-bom-pcbway.csv` (MPN, maker, LCSC # for reference, notes)
   - Centroid: `production/canary-cpl.csv`; drawing: `production/canary-assembly.pdf`
   - J1 (USB-C) has four plated shell slots — pin-in-paste/hand-solder as PCBWay prefers.
   - Sensirion parts (U3 SGP40, U4 SHT40, U5 SCD41): **no washing, no conformal coating**.
3. **Programming** (PCBWay offers it; ask in the order notes): flash
   `production/canary.hex` to U2 (ATmega328P) through the Tag-Connect TC2030
   pads (J2, standard 6-pin AVR ISP pinout), with fuses
   **lfuse 0xE2, hfuse 0xD9, efuse 0xFD** (internal 8 MHz, no clock divider,
   brown-out 2.7 V). To do it yourself: a USBasp + TC2030-IDC-NL cable, then
   `make -C firmware flash`.

## Case

`enclosure/print/canary-v1-bumper.stl` is an optional printed frame (PLA/PETG, no
supports, 64 × 44 × 5 mm). The board presses in from below; its underside
stays flush with the frame's so the thermal tab still lies on the pack, and
the USB-C, probe connector and the sensor head's air path stay open.

## Bring-up

1. Plug a USB-C cable from any phone charger. Green blinks for 90 s (gas
   sensor warm-up), then breathes slowly.
2. Press TEST/HUSH: green, amber, red sweep, a short beep, and the SGP40
   self-test runs. A fault shows as an amber double blink with a chirp every
   minute.
3. Telemetry: TXD pad, 3.3 V, **38400 8N1**, one line a second
   (`t= st= tp= ... sraw= co2= rate= dtdt= e= f=`).
4. Use: lay the board on the pack with the **thermal tab** touching it (or
   plug a 10 kΩ B3950 NTC probe into the JST-PH and tape it to the pack), the
   sensor head ("AIR IN") facing the air above the pack.

## Limits — read these

- **Not a certified safety device.** Keep your smoke alarm.
- **The thresholds are not yet validated against a real venting cell.** The
  simulated worlds use stated assumptions (SGP40 drop of thousands of ticks,
  CO₂ rising by thousands of ppm within a minute, accelerating self-heating),
  based on how first vent is described for commercial off-gas detectors. A
  real abuse test (a cell vented beside the board, in a safe facility) is the
  next step, and the thresholds in `firmware/src/detect.h` may move.
- No battery backup: if the outlet loses power, Canary is off.
- Placement matters: the gas and CO₂ sensors need the vent plume to reach
  them; inside a closed bag or a frame with no airflow, use the probe and
  expect slower gas detection.
- The ATmega328P has no USB: firmware updates need an ISP programmer.
- 3D models for SGP40, SHT40, SCD41, the sounder and the JST connector are
  simple dimensioned boxes made by `src/models3d.py` (KiCad 10.0.6 ships none).

## Files

| Path | What |
|---|---|
| `production/` | Gerber zip, PCBWay BOM, CPL, netlist, assembly + schematic PDFs, firmware HEX |
| `canary.kicad_sch`, `canary.kicad_pcb`, `canary.kicad_pro` | KiCad 10 design (generated) |
| `src/` | the design source: `circuit.py` (every part and net), `schematic.py`, `board.py`, `miter.py`, `finish.py`, `fab.py`, checks |
| `firmware/` | AVR C firmware (`detect.c` is the detector logic) |
| `sim/hil/` | simavr hardware-in-the-loop harness + scenarios |
| `sim/spice/`, `sim/analysis/` | sounder driver SPICE, NTC/power/I²C analyses |
| `video/` | the scripts that build the narrated product video (the MP4 is published, not committed) |
| `web/` | the interactive bench page (`build_page.py` → one HTML file); its detector is a port of `detect.c` checked equal to the firmware second by second |

Parts:
BZ1: CMT-8504; MagneticBuzzer_CUI_CMT-8504-100-SMT; MPN CMT-8504-100-SMT-TR; LCSC C22359707
C1, C2, C9, C13: 10u; C_0805_2012Metric; MPN CL21A106KAYNNNE; LCSC C15850
C3, C4, C5, C6, C8, C10, C11, C12: 100n; C_0603_1608Metric; MPN CL10B104KA8NNNC; LCSC C1590
C7: 1u; C_0603_1608Metric; MPN CL10A105KA8NNNC; LCSC C5673
D1: SMF5.0A; D_SMF; MPN SMF5.0A; LCSC C151296
D2: B5819W; D_SOD-123; MPN B5819W-TP; LCSC C84354
D3: Green; LED_0603_1608Metric; MPN APT1608SGC; LCSC C5875754
D4: Amber; LED_0603_1608Metric; MPN APT1608SYCK; LCSC C5875726
D5: Red; LED_0603_1608Metric; MPN APT1608EC; LCSC C5554143
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
H1, H2: M2; MountingHole_2.2mm_M2
J1: USB-C power; USB_C_Receptacle_GCT_USB4125-xx-x-0190_6P_TopMnt_Horizontal; MPN USB4125-GF-A-0190; LCSC C5246813
J2: ISP (Tag-Connect); Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical; MPN TC2030-IDC-NL
J3: Probe; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal; MPN S2B-PH-SM4-TB(LF)(SN); LCSC C295747
Q1: AO3400A; SOT-23; MPN AO3400A; LCSC C20917
R1, R2: 5.1k; R_0603_1608Metric; MPN RC0603FR-075K1L; LCSC C105580
R3, R14: 10k; R_0603_1608Metric; MPN RC0603FR-0710KL; LCSC C98220
R4, R5: 4.7k; R_0603_1608Metric; MPN RC0603FR-074K7L; LCSC C99782
R6, R7: 10k 0.1%; R_0603_1608Metric; MPN RT0603BRD0710KL; LCSC C95204
R8, R11, R12: 1k; R_0603_1608Metric; MPN RC0603FR-071KL; LCSC C22548
R9: 100; R_0603_1608Metric; MPN RC0603FR-07100RL; LCSC C105588
R10: 100k; R_0603_1608Metric; MPN RC0603FR-07100KL; LCSC C14675
R13: 470; R_0603_1608Metric; MPN RC0603FR-07470RL; LCSC C114669
SW1: TEST / HUSH; SW_SPST_TL3342; MPN TL3342F160QG/TR; LCSC C2886898
TH1: 10k B3380; R_0603_1608Metric; MPN NCU18XH103F60RB; LCSC C440252
TP1: TXD; TestPoint_Pad_D1.0mm
TP2: RXD; TestPoint_Pad_D1.0mm
TP3: GND; TestPoint_Pad_D1.0mm
U1: AP2112K-3.3; SOT-23-5; MPN AP2112K-3.3TRG1; LCSC C51118
U2: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm; MPN ATMEGA328P-AU; LCSC C14877
U3: SGP40; Sensirion_DFN-6_2.44x2.44mm_P0.8mm_SGP40; MPN SGP40-D-R4; LCSC C2874215
U4: SHT40; Sensirion_DFN-4_1.5x1.5mm_P0.8mm_SHT4x_NoCentralPad; MPN SHT40-AD1B-R2; LCSC C2909890
U5: SCD41; Sensirion_SCD4x-1EP_10.1x10.1mm_P1.25mm_EP4.8x4.8mm; MPN SCD41-D-R2; LCSC C3659294

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C7.1, C8.1, C9.1, C10.1, J2.2 (VCC), R3.1, R4.1, R5.1, R6.1, R7.1, R14.1, U1.5 (VOUT), U2.4 (VCC), U2.6 (VCC), U2.18 (AVCC), U3.1 (VDD), U3.5 (VDDH), U4.3 (VDD), U5.7 (VDD), U5.19 (VDD)
/AREF: C6.1, U2.20 (AREF)
/BTN: R14.2, SW1.1, U2.32 (PD2)
/BUZ: R9.1, U2.13 (PB1)
/BUZ_D: BZ1.2 (-), D2.2 (A), Q1.3 (D)
/BUZ_G: Q1.1 (G), R9.2, R10.1
/CC1: J1.A5 (CC1), R1.1
/CC2: J1.B5 (CC2), R2.1
/LED_AMB: R12.1, U2.9 (PD5)
/LED_AMB_A: D4.2 (A), R12.2
/LED_GRN: R11.1, U2.1 (PD3)
/LED_GRN_A: D3.2 (A), R11.2
/LED_RED: R13.1, U2.10 (PD6)
/LED_RED_A: D5.2 (A), R13.2
/MISO: J2.1 (MISO), U2.16 (PB4)
/MOSI: J2.4 (MOSI), U2.15 (PB3)
/NTC_BRD: C11.1, R6.2, TH1.1, U2.23 (PC0)
/NTC_PRB: J3.1, R7.2, R8.1
/NTC_PRB_F: C12.1, R8.2, U2.24 (PC1)
/RESET: J2.5 (~RST), R3.2, U2.29 (~RESET/PC6)
/RXD: TP2.1, U2.30 (PD0)
/SCK: J2.3 (SCK), U2.17 (PB5)
/SCL: R5.2, U2.28 (PC5), U3.6 (SCL), U4.2 (SCL), U5.9 (SCL)
/SDA: R4.2, U2.27 (PC4), U3.3 (SDA), U4.1 (SDA), U5.10 (SDA)
/TXD: TP1.1, U2.31 (PD1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, D1.2 (A2), D3.1 (K), D4.1 (K), D5.1 (K), J1.A12 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.6 (GND), J3.2, J3.MP (MountPin), Q1.2 (S), R1.2, R2.2, R10.2, SW1.2, TH1.2, TP3.1, U1.2 (GND), U2.3 (GND), U2.5 (GND), U2.21 (GND), U3.2 (VSS), U3.4 (GND), U3.7 (EP), U4.4 (VSS), U5.6 (GND), U5.20 (GND), U5.21 (GND)
VBUS: BZ1.1 (+), C1.1, C13.1, D1.1 (A1), D2.1 (K), J1.A9 (VBUS), J1.B9 (VBUS), U1.1 (VIN), U1.3 (EN)

Notes on the sheet:
POWER — USB-C 5 V in, TVS, 3.3 V LDO
MCU — ATmega328P, internal 8 MHz
SENSORS — VOC (SGP40), CO2 (SCD41), RH/T (SHT40)
TEMPERATURE — on-board tab NTC + optional probe
ALARM — 4 kHz 100 dB sounder, low-side switch
INDICATION & TEST/HUSH
PROGRAMMING (Tag-Connect TC2030) & TEST PADS
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
Board: 2 copper layers, 60.0 x 40.0 mm, 52 parts (0 on the bottom side), 27 nets.

## KiCad design products/mesh-radio/mesh-radio.kicad_pcb

File products/mesh-radio/README.md (part):

# Mesh Radio

**A LoRa mesh radio on one narrow board, built only from parts a US or
allied factory can buy and assemble.** It does what the RAK WisBlock does in
OffGrid's mesh nodes today (Meshtastic over LoRa, set up from the phone over
Bluetooth), on a single board shaped like a Heltec V4. It also has a
transmit amplifier that goes past the legal 1 W for licensed or experimental
use, a locking serial port for the Cairn drone, and protection on every
input.

> **Status: re-routed, DRC 0/0/0, fab files made, every simulation re-run
> on the routed board (5 Nov 2026). Not yet built.**
>
> - **Board:** 70 × 25.4 mm, 6 layers, an M3 hole in each corner, every cable plug on one long edge (JLCPCB JLC06161H-2116B: In1 solid
>   ground under the radio lines and the antenna, signals elsewhere on In1–In4 with ground fill). 257 parts, 251 of them
>   assembled, on both sides.
> - **Routed.** KiCad DRC 0 errors, 0 warnings, 0 unconnected; copper nets
>   equal the circuit pad for pad. Gerbers, BOM, CPL, assembly drawing and
>   STEP are in [`production/`](production/) and [`mechanical/`](mechanical/);
>   renders in [`images/`](images/).
> - **Simulations** (power, radio, heat) re-ran on the re-routed board
>   (5 Nov). Still failing: transmitting above 1 W in a hot box (the heat
>   study's duty table). The antenna switch's overload with the antenna
>   missing at 4.0 V is handled by a firmware ceiling (checked by
>   simulation only). Results: [`TESTS.md`](TESTS.md).
> - **Firmware:** the Meshtastic variant builds. Nothing has run on
>   hardware.
> - **Owner decisions, 19 Oct:** keep 3 W and fix the heat (a gap pad to a
>   metal enclosure, nine filled vias under the amplifier); 6 layers; the
>   designer picks the new parts; charging at 300 mA.
>
> Nothing is ordered or measured. Every test and its result:
> [`TESTS.md`](TESTS.md).

## Revisions

This folder always holds the latest revision; an ordered revision stays at
its order tag ([`docs/versioning.md`](../../docs/versioning.md)). Mesh Radio is a
working name until the owner picks one before the first order. It replaces
the RAK WisBlock (RAK4631 on a RAK19003) in OffGrid's mesh nodes, starting
with Cairn (formerly Project Cheap Drone Phase 2); Meshtastic first, MeshCore
later.

| Revision | What changed | Status | Order tag |
|---|---|---|---|
| 1.0 | first design | re-routed for the routed-board studies (5 Nov), DRC 0/0/0, every simulation re-run; not yet built | — |

## This revision

| | |
|---|---|
| Revision | **1.0**, printed `V1` on the board (`REV` in `src/silk.py`; [Revisions](#revisions)) |
| Status | re-routed (70 × 25.4 mm, 6 layers, 5 Nov), DRC 0/0/0, fab files made; not yet built |
| Plan | [`docs/plan.md`](docs/plan.md) |
| Schematic | [`schematic/`](schematic/) (KiCad 10 project + PDF), generated by `src/sch.py` from `src/circuit.py` |
| Layout | [`mesh-radio.kicad_pcb`](mesh-radio.kicad_pcb): placement `src/placement.json`, routed by `src/pipeline.py` (below) |
| Simulations | [`sim/`](sim/): power, radio and heat, on the re-routed board (5 Nov) |
| Firmware | [`firmware/`](firmware/): Meshtastic variant builds against v2.7.26 (19 Oct); provisional power table |
| Parts cost | $68.22 per board at 100, $87.26 at 10 (parts only, DigiKey prices, 19 Oct: [`docs/part-audit.md`](docs/part-audit.md)) |
| Part audit | [`docs/part-audit.md`](docs/part-audit.md) |
| Trade-offs and research | [`docs/decisions.md`](docs/decisions.md) |
| Tests and simulations | [`TESTS.md`](TESTS.md): every one with its revision 1.0 result so far |
| Toolchain | KiCad 10.0.7 (pinned image, `tools/Dockerfile`) |

## Requirements

Set by the owner on 17 Oct 2026, with the evidence for each in
[`docs/decisions.md`](docs/decisions.md). Each requirement says how it will
be checked. The *v1* column is from the re-routed board's checks and simulations (5–6 Nov 2026).

- ✅ checked and passed so far (in simulation, in the parts or in the
  routed layout). Hardware still has to confirm it.
- ⏳ not yet checked, or only partly.
- ❌ not met, or fails a check. The note says why.

### Sourcing and compliance

| # | Requirement | How it is checked | v1 |
|---|---|---|---|
| S1 | **No part from a Chinese, Russian, Iranian or North Korean company, and none from Huawei, ZTE, Hytera, Hikvision or Dahua.** Every part comes from a US, EU, UK, Japanese, Taiwanese, Korean, Swiss or Norwegian maker. | BOM audit listing each part's maker and headquarters | ✅ every maker is from the US, Japan, Taiwan, Korea, Norway or Germany; the BOM locks the genuine LCSC numbers, not the Chinese clones JLC lists under the same part numbers (`docs/part-audit.md`, 19 Oct) |
| S2 | **Every part is in production today and stocked at DigiKey**, with a second source where one exists | Dated DigiKey stock and lifecycle check in `docs/` | ⏳ checked 19 Oct: no part is last-time-buy; lines out of stock at DigiKey have a non-Chinese second source named. The 8.1 nH choke is not sold at DigiKey (Coilcraft direct). The 0805 inductors LQW2BAN3N2/3N6 have none at LCSC/JLCPCB (6 Nov): consign or pre-order (*Ordering*). Re-check before ordering (`docs/part-audit.md`). |
| S3 | **The same files build at JLCPCB/PCBWay (test boards) and at a US or allied assembler (compliant boards)**, with no redesign. Test boards from China are *not* NDAA compliant and must never be described as such. | Every part has a DigiKey part number and an LCSC part number; no JLC-only parts | ⏳ every assembled part has an LCSC number (`src/make.py` gate, 5 Nov); every line has a DigiKey number except the 8.1 nH choke. Parts not stocked at LCSC are sent to JLCPCB from DigiKey (*Ordering*, `docs/part-audit.md`). |
| S4 | Country of origin recorded for every chip, so a compliance file can be built later | BOM column | ❌ not yet recorded: DigiKey's pages do not show it. Collect it from the distributor or the assembler for a compliant build (`docs/part-audit.md`). |

### Radio

| # | Requirement | How it is checked | v1 |
|---|---|---|---|
| R1 | **LoRa, 902–928 MHz (US)**, Semtech SX1262, compatible with Meshtastic and MeshCore | Firmware variant builds; pins match firmware source | ✅ variant builds (6 Nov, v2.7.26 with the core patch); SX1262 on the RAK4631's pins (`firmware/README.md`). ⏳ on hardware. |
| R2 | **Transmit power adjustable from about 10 mW to about 3 W (35 dBm) into the antenna**, in bursts | PA datasheet and supply simulation at full battery; measured on built boards | ✅ in simulation on the routed board (5 Nov): the supply and a fresh cell carry 3 W bursts at 0 to 85 °C, 2.5 W at −20 °C, 2 W at −40 °C (`sim/burst`); 34.7–35.1 dBm at 4.0 V over tolerance (`sim/rf`); about 6 mW at the lowest setting (`firmware/README.md`). Heat sets the real ceiling, and on the board as ordered it is below 3 W: the firmware's temperature cap allows 3 W below 45 °C on the board, but that cap assumes heat fixes this board does not have (see *Limits — read these*; a change to the cap is waiting on the owner). ⏳ measured. |
| R3 | **1 W (30 dBm) whenever the radio is set to the US region**, the Part 15 limit. Above 1 W only in Meshtastic's licensed (ham) mode or with custom firmware. | Firmware power table (`TX_GAIN_LORA`) from the PA's gain; measured | ⏳ table written from a model: a 30 dBm request gives about 29.0 dBm. Needs the core patch (part 1) and bench measurement (`firmware/README.md`). |
| R4 | Receive at least as well as the RAK4631 (SX1262 sensitivity, about −131 dBm at LongFast). The amplifier's receive path must not make it worse. | Noise-figure budget; measured side by side with a RAK | ✅ in simulation on the routed board (5 Nov): 4.9 dB better than a RAK4631 with the receive amp on (the default); 2.1 dB worse in battery-saver bypass (`sim/rf`). ⏳ side by side. |

Notes on the sheet:
USB: 22 V flat-clamp TVS, a 4.7 uF + 1 R snubber and a TPS259470A eFuse (cut-off 5.4 V, 1.5 A). Solar and drone: 33 V TVS and a 60 V MAX17608 (cut-off 10 V, 0.71 A, blocks -60 V and reverse current).
Battery plug wired the Adafruit/SparkFun way (pad 1 = +). Cell protection on the minus side (OCD ~5.8 A, SCD ~29 A, OV 4.275 V, UV 2.8 V); reverse-battery P-FET on the plus side, on only when the cell is the right way round. Charge 300 mA. Current-limited cell-to-SYS bypass.
The slide switch drives only enables (3.3 V buck, cell bypass); charging works with the board off.
nRF52840 in normal-voltage mode: VDD = VDDH = the 3.3 V rail, so its pins and the SX1262 share one logic level. REG1 DC/DC on (10 uH + 15 nH). Nordic reference circuit, aQFN73.
Semtech SX1262MB2CAS (915 MHz) reference values. TCXO on DIO3 (set 2.2 V in firmware), DIO2 drives the antenna switch.
Drive: SX1262 +11 dBm -> 30 dBm (1 W), +17 dBm -> ~35 dBm (3 W). The 15.9 dB pad keeps the amplifier input below its +13 dBm limit even at the SX1262 maximum (+22 dBm -> +6 dBm).
Amplifier runs from the battery through a power mux (battery first down to 2.6 V; firmware selects charger SYS when no cell is fitted), then a TPS63810 buck-boost (I2C 0x75): 2.7 V for 1 W, 4.0 V for 3 W.
Drone port wired as Pixhawk TELEM (pins from the autopilot side): 1 5V, 2 TX, 3 RX, 4 CTS, 5 RTS, 6 GND. Series resistors and ESD on every external signal.
Mesh Radio v1 (working name) - OffGrid Devices LoRa 902-928 MHz mesh radio, up to ~3 W; Bluetooth LE; one LiPo cell; USB-C, solar and drone power. NDAA-ready parts list: every part from a US / EU / Japan / Taiwan / Korea / Norway maker. Each box below is one page. Every connection is a named label;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

Parts:
C1: 100pF; C_0402; MPN GRM1555C1H101JA01D; DigiKey 490-5922-1-ND
C2, C3: 1nF; C_0402; MPN GRM1555C1H102JA01D; DigiKey 490-3244-1-ND
C4, C7, C8: 1uF; C_0603; MPN UMK107BJ105KA-T; DigiKey 587-2400-1-ND
C5: 4.7uF; C_1206; MPN CL31B475KBHNNNE; DigiKey 1276-2789-1-ND
C6: 4.7uF; C_0603; MPN CL10A475KP8NNNC; DigiKey 1276-1044-1-ND
D1: TPD4E05U06DQAR; USON-10_L2.5-W1.0-P0.50-BL; MPN TPD4E05U06DQAR; DigiKey 296-35765-1-ND
D2: TVS2200DRVR; WSON-6_L2.0-W2.0-P0.65-BL-EP; MPN TVS2200DRVR; DigiKey 296-52187-1-ND
D3: 5.6V; SOD-323FL; MPN UDZVTE-175.6B; DigiKey UDZVTE-175.6BCT-ND
D4: RB060MM-30; SOD-123FL; MPN RB060MM-30TR; DigiKey RB060MM-30CT-ND
D5, D6: SMF33CA; SOD-123FL; MPN SMF33CA; DigiKey 18-SMF33CACT-ND
J1: 12401610E4#2A; USB-C-SMD_TYPE-C-24P; MPN 12401610E4#2A; DigiKey 12401610E4#2ACT-ND
J2: SM02B-SRSS-TB(LF)(SN); CONN-SMD_2P-P1.00_SM02B-SRSS-TB-LF-SN; MPN SM02B-SRSS-TB(LF)(SN); DigiKey 455-SM02B-SRSS-TBCT-ND
R1, R2: 5.1k; R_0402; MPN RC0402FR-075K1L; DigiKey 311-5.10KLRCT-ND
R3: 20k; R_0402; MPN RC0402FR-0720KL; DigiKey 311-20.0KLRCT-ND
R4: 7.68k; R_0402; MPN RC0402FR-077K68L; DigiKey YAG3237CT-ND
R5, R13, R19: 1M; R_0402; MPN RC0402FR-071ML; DigiKey 311-1.00MLRCT-ND
R6: 287k; R_0402; MPN RC0402FR-07287KL; DigiKey YAG3088CT-ND
R7: 2.21k; R_0402; MPN RC0402FR-072K21L; DigiKey 311-2.21KLRCT-ND
R8: 1R; R_0805; MPN CRCW08051R00FKEAHP; DigiKey 541-1.00TCT-ND
R9: 2.2k; R_0402; MPN RC0402FR-072K2L; DigiKey 311-2.20KLRCT-ND
R10: 22R; R_0402; MPN RC0402FR-0722RL; DigiKey 311-22.0LRCT-ND
R11, R15, R17, R21: 1.5M; R_0402; MPN RC0402FR-071M5L; DigiKey 13-RC0402FR-071M5LCT-ND
R12, R18: 267k; R_0402; MPN RC0402FR-07267KL; DigiKey YAG3079CT-ND
R14, R20: 2.1k; R_0402; MPN RC0402FR-072K1L; DigiKey YAG3098CT-ND
R16, R22: 100k; R_0402; MPN RC0402FR-07100KL; DigiKey 311-100KLRCT-ND
U1: TPS259470ARPWR; VQFN-10_L2.0-W2.0-P0.45-TL; MPN TPS259470ARPWR; DigiKey 296-TPS259470ARPWRCT-ND
U2, U3: MAX17608ATC+T; TDFN-12_L3.0-W3.0-P0.50-BL-EP; MPN MAX17608ATC+T; DigiKey 175-MAX17608ATC+TCT-ND

Connections:
DRN_OV: R17.2, R18.1, U3.3 (OVLO)
DRN_SETI: R20.1, U3.8 (SETI)
DRN_UV: R19.2, U3.4 (UVLO)
DRONE_5V_CONN: C8.1, D6.1 (A1), R17.1, R19.1, R21.1, U3.1 (IN), U3.2 (IN); also elsewhere on the board
DRONE_OK: R21.2, R22.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, D1.3 (GND), D1.8 (GND), D2.1 (GND), D2.2 (GND), D2.3 (GND), D2.7 (GND (EP)), D3.2 (A), D5.2 (A2), D6.2 (A2), J1.14 (SHIELD), J1.15 (SHIELD), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.2, R1.2, R2.2, R4.2, R6.2, R7.2, R8.2, R9.2, R12.2, R14.2, R16.2, R18.2, R20.2, R22.2, U1.8 (GND), U2.6 (CLMODE), U2.7 (GND), U2.13 (GND (EP)), U3.6 (CLMODE), U3.7 (GND), U3.13 (GND (EP)); also elsewhere on the board
NRF_VBUS: C6.1, R10.2; also elsewhere on the board
SOLAR_CONN: C7.1, D5.1 (A1), J2.1, R11.1, R13.1, R15.1, U2.1 (IN), U2.2 (IN)
SOLAR_OK: R15.2, R16.1; also elsewhere on the board
SOL_OV: R11.2, R12.1, U2.3 (OVLO)
SOL_SETI: R14.1, U2.8 (SETI)
SOL_UV: R13.2, U2.4 (UVLO)
USB_5V: D4.2 (A), R9.1, R10.1, U1.6 (OUT)
USB_CC1: D1.4 (IO3), J1.A5 (CC1), R1.1
USB_CC2: D1.5 (IO4), J1.B5 (CC2), R2.1
USB_DM: D1.2 (IO2), J1.A7 (D-), J1.B7 (D-); also elsewhere on the board
USB_DP: D1.1 (IO1), J1.A6 (D+), J1.B6 (D+); also elsewhere on the board
USB_DVDT: C2.1, U1.7 (DVDT)
USB_ILM: R7.1, U1.9 (ILM)
USB_OV: C1.1, R5.2, R6.1, U1.2 (OVLO)
USB_SNB: C5.2, R8.1
USB_TMR: C3.1, U1.10 (ITIMER)
USB_UV: D3.1 (K), R3.2, R4.1, U1.1 (EN/UVLO)
USB_VBUS: C4.1, C5.1, D2.4 (IN), D2.5 (IN), D2.6 (IN), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R3.1, R5.1, U1.5 (IN)
VIN_CHG: D4.1 (K), U2.11 (OUT), U2.12 (OUT), U3.11 (OUT), U3.12 (OUT); also elsewhere on the board

Notes on the sheet:
Power in: USB-C, solar, drone 5 V (each surge-clamped and fused)
USB: 22 V flat-clamp TVS, a 4.7 uF + 1 R snubber and a TPS259470A eFuse (cut-off 5.4 V, 1.5 A). Solar and drone: 33 V TVS and a 60 V MAX17608 (cut-off 10 V, 0.71 A, blocks -60 V and reverse current).
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

Notices in the files:
canary/v1/canary.kicad_pcb:
OffGrid Devices  CERN-OHL-S v2
