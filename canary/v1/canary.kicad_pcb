# Repository offgridevices/offgrid-hardware (continued)

## KiCad design products/mesh-radio/mesh-radio.kicad_pcb (continued)

Parts:
C54, C64, C70: 47pF; C_0402; MPN GJM1555C1H470JB01D; DigiKey 490-14446-1-ND
C55, C59, C66, C67, C81: 10nF; C_0402; MPN CL05B103KB5NNNC; DigiKey 1276-1028-1-ND
C56, C60, C69, C82, C83, C84, C99: 1nF; C_0402; MPN GRM1555C1H102JA01D; DigiKey 490-3244-1-ND
C57, C62, C63: 27pF; C_0402; MPN GJM1555C1H270JB01D; DigiKey 490-17672-1-ND
C58, C68: 4.7uF; C_0603; MPN CL10A475KP8NNNC; DigiKey 1276-1044-1-ND
C61: 15pF; C_0402; MPN GJM1555C1H150JB01D; DigiKey 490-3117-1-ND
C65: 1.5pF; C_0402; MPN GJM1555C1H1R5BB01D; DigiKey 490-8087-1-ND
C71: 15pF; C_0603; MPN GQM1875C2E150JB12D; DigiKey 490-14794-1-ND
C72: 10pF; C_0603; MPN GQM1875C2E100JB12D; DigiKey 490-6086-1-ND
C73: 5.6pF; C_0603; MPN GQM1875C2E5R6CB12D; DigiKey 490-7162-1-ND
C74: 47pF; C_0603; MPN GQM1875C2E470JB12D; DigiKey 490-5900-1-ND
C75, C77: 2.2pF; C_0603; MPN GQM1875C2E2R2BB12D; LCSC C2179335
C76: 3.0pF; C_0603; MPN GQM1875C2E3R0BB12D; LCSC C2178931
C78: 0.9pF; C_0603; MPN GQM1875C2ER90BB12D; DigiKey 490-GQM1875C2ER90BB12DCT-ND
C79: 1.5pF; C_0603; MPN GQM1875C2E1R5BB12D; LCSC C3869699
C80: 100pF; C_0402; MPN GRM1555C1H101JA01D; DigiKey 490-5922-1-ND
C85: 100nF; C_0402; MPN CL05B104KO5NNNC; DigiKey 1276-1001-1-ND
D9, D14: BAT6804WH6327XTSA1; SOT-323; MPN BAT6804WH6327XTSA1; DigiKey BAT6804WH6327XTSA1CT-ND
FB1, FB2: 10R@100MHz; L_0402; MPN BLM15AG100SN1D; DigiKey 490-5176-1-ND
FL1: LFCG-1000+; FILTER-SMD_8P-L2.0-W1.3-BL_LFCG-XX; MPN LFCG-1000+; DigiKey 3157-LFCG-1000+CT-ND
J4: U.FL-R-SMT-1(80); RF-SMD_FRF05002-JSS103M; MPN U.FL-R-SMT-1(80); DigiKey 26-U.FL-R-SMT-1(80)CT-ND
L12: 11nH; L_0603; MPN LQW18AN11NG00D; DigiKey 490-6859-1-ND
L13: 1.6nH; L_0402; MPN LQG15HS1N6S02D; DigiKey 490-8388-1-ND
L14: 8.1nH; L_0908SQ; MPN 0908SQ-8N1; LCSC C19191636
L15, L17: 3.6nH; L_0805; MPN LQW2BAN3N6J00L; DigiKey 490-16042-1-ND
L16: 3.2nH; L_0805; MPN LQW2BAN3N2J00L; DigiKey 490-16041-1-ND
L18: 47nH; L_0402; MPN LQW15AN47NJ00D; DigiKey 490-1154-1-ND
L19: 11nH; L_0402; MPN LQW15AN11NJ00D; DigiKey 490-6766-1-ND
R46: 68R; R_0805; MPN RCS080568R0FKEA; DigiKey 541-10549-1-ND
R47: 150R; R_0805; MPN RC0805FR-07150RL; DigiKey 311-150CRCT-ND
R48: 68R; R_0805; MPN RC0805FR-0768RL; DigiKey 311-68.0CRCT-ND
R49: 220k; R_0402; MPN RC0402FR-07220KL; DigiKey 311-220KLRCT-ND
R50: 330k; R_0402; MPN RC0402FR-07330KL; DigiKey 311-330KLRCT-ND
R51: 49.9R; R_0805; MPN CRCW080549R9FKEAHP; DigiKey 541-49.9TCT-ND
R52, R74: 100k; R_0402; MPN RC0402FR-07100KL; DigiKey 311-100KLRCT-ND
R75: 49.9R; R_0402; MPN RC0402FR-0749R9L; DigiKey 311-49.9LRCT-ND
U10: QPA9510TR7; QFN-16_3x3_QPA9510; MPN QPA9510TR7; DigiKey 2312-QPA9510TR7CT-ND
U11: SKY13330-397LF; QFN-12_L2.0-W2.0-P0.50-BL-EP0.8; MPN SKY13330-397LF; DigiKey 863-1643-1-ND
U12: BGA7L1BN6E6327XTSA1; TSNP-6_L1.1-W0.7-P0.40-BL; MPN BGA7L1BN6E6327XTSA1; DigiKey BGA7L1BN6E6327XTSA1CT-ND

Connections:
3V3: C80.1, C81.1, C84.1, C85.1, R49.1, U11.9 (VBATT), U12.2 (VCC); also elsewhere on the board
ANT: FL1.4 (RF OUT), J4.1 (SIG), L18.1
ANT_SW: FL1.8 (RF IN), U11.2 (RF1 (ANT))
FWD_DET: C99.1, D14.2 (K2), D14.3 (K1/A2), R74.1; also elsewhere on the board
GND: C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C75.2, C77.2, C79.2, C80.2, C81.2, C82.2, C84.2, C85.2, C99.2, FL1.1 (GND), FL1.2 (GND), FL1.3 (GND), FL1.5 (GND), FL1.6 (GND), FL1.7 (GND), J4.2 (GND), J4.3 (GND), L18.2, R46.2, R48.2, R50.2, R51.2, R52.2, R74.2, R75.2, U10.2 (GND1), U10.4 (GND2), U10.17 (GND (EP)), U11.1 (GND), U11.3 (GND), U11.4 (GND), U11.6 (GND), U11.10 (GND), U11.12 (GND), U11.13 (GND (EP)), U12.1 (GND), U12.4 (GND); also elsewhere on the board
LNA_AI: L19.2, U12.5 (AI)
LNA_EN: U12.6 (C); also elsewhere on the board
LNA_INM: C83.2, L19.1
LNA_OUT: U12.3 (AO); also elsewhere on the board
LORA_TX50: R46.1, R47.1; also elsewhere on the board
PA_2F0: C65.1, U10.8 (2F0)
PA_APC: C66.1, C67.1, U10.15 (APC2), U10.16 (APC1); also elsewhere on the board
PA_DRIVE: C54.1, R47.2, R48.1
PA_M1: C73.1, C74.1, L15.2
PA_M2: C74.2, C75.1, C76.1, L16.1
PA_M3: C76.2, C77.1, C78.1, L16.2, L17.1
PA_OUT: C71.1, C72.1, L14.2, L15.1, U10.9 (RF OUT), U10.10 (RF OUT), U10.11 (RF OUT), U10.12 (RF OUT)
PA_RFIN: C54.2, U10.3 (RF IN)
PA_TX: C78.2, C79.1, L17.2, U11.11 (RF2 (TX))
PA_V1F: C55.1, C56.1, C57.1, FB1.2, L12.1
PA_V2F: C61.1, FB2.2, L13.1
PA_VCC1: L12.2, U10.1 (VCC1)
PA_VCC2: C62.1, C63.1, L13.2, U10.5 (VCC2), U10.6 (VCC2)
REFL_CPL: D9.1 (A1), D14.1 (A1), R51.1, R75.1
REFL_DET: C82.1, D9.2 (K2), D9.3 (K1/A2), R52.1; also elsewhere on the board
RF_SW_CTRL: U11.7 (CTRL); also elsewhere on the board
RF_SW_EN: R49.2, R50.1, U11.8 (ENABLE)
RX_SW: C83.1, U11.5 (RF3 (RX))
VPA: C58.1, C59.1, C60.1, C64.1, C68.1, C69.1, C70.1, FB1.1, FB2.1, L14.1, U10.14 (VCC (bias)); also elsewhere on the board

Notes on the sheet:
RF front end: 15 dB pad, 3 W amplifier, filters, antenna switch, LNA
Drive: SX1262 +11 dBm -> 30 dBm (1 W), +17 dBm -> ~35 dBm (3 W). The 15.9 dB pad keeps the amplifier input below its +13 dBm limit even at the SX1262 maximum (+22 dBm -> +6 dBm).

Parts:
C86: 10nF; C_0402; MPN CL05B103KB5NNNC; DigiKey 1276-1028-1-ND
C87, C88: 1uF; C_0603; MPN CL10B105KA8NNNC; DigiKey 1276-1184-1-ND
C89, C90: 22uF; C_0805; MPN GRM21BR61C226ME44L; DigiKey 490-10747-1-ND
C91: 10uF; C_0805; MPN CL21A106KAYNNNE; DigiKey 1276-2891-1-ND
C92, C93: 47uF; C_1206; MPN C3216X7S0J476M160AC; DigiKey 445-8037-1-ND
C94, C97: 100nF; C_0402; MPN CL05B104KO5NNNC; DigiKey 1276-1001-1-ND
C95, C96: 1uF; C_0402; MPN CL05A105KO5NNNC; DigiKey 1276-1067-1-ND
L20: 0.47uH; L_1008; MPN DFE252012F-R47M=P2; DigiKey 490-13049-1-ND
Q4, Q5: SSM3K56ACT; SOT-883; MPN SSM3K56ACT,L3F; DigiKey SSM3K56ACTL3FCT-ND
R53: 562k; R_0402; MPN RC0402FR-07562KL; DigiKey 311-562KLRCT-ND
R54: 374k; R_0402; MPN RC0402FR-07374KL; DigiKey YAG3136CT-ND
R55, R56, R58: 1M; R_0402; MPN RC0402FR-071ML; DigiKey 311-1.00MLRCT-ND
R57: 22.1k; R_0402; MPN RC0402FR-0722K1L; DigiKey 311-22.1KLRCT-ND
R59, R60: 100k; R_0402; MPN RC0402FR-07100KL; DigiKey 311-100KLRCT-ND
R61, R62: 4.7k; R_0402; MPN RC0402FR-074K7L; DigiKey 311-4.7KLRCT-ND
U13: TPS2121RUXR; VQFN-12_TPS2121RUX; MPN TPS2121RUXR; DigiKey 296-53410-1-ND
U14: TPS63810YFFR; DSBGA-15_L2.2-W1.4-R3-V5-P0.40-BL; MPN TPS63810YFFR; DigiKey 296-TPS63810YFFRCT-ND
U15: TLV75528PDQNR; X2SON-4_L1.0-W1.0-P0.65-TL-EP; MPN TLV75528PDQNR; DigiKey 296-TLV75528PDQNRCT-ND
U16: TMP1075NDRLR; SOT-563_L1.6-W1.2-P0.50-LS1.6-BR; MPN TMP1075NDRLR; DigiKey 296-TMP1075NDRLRCT-ND

Connections:
3V3: C95.1, C97.1, R60.2, R61.2, R62.2, U15.4 (IN), U16.5 (V+); also elsewhere on the board
BAT_P: C87.1, R53.1, R56.1, U13.7 (IN1); also elsewhere on the board
GND: C86.2, C87.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2, C94.2, C95.2, C96.2, C97.2, Q4.2 (S), Q5.2 (S), R54.2, R55.2, R57.2, R58.2, R59.2, U13.3 (CP2), U13.9 (ST), U13.12 (GND), U14.B1 (VSEL), U14.C1 (AGND), U14.C2 (GND), U14.C3 (GND), U15.2 (GND), U15.5 (GND (EP)), U16.2 (GND), U16.4 (A0); also elsewhere on the board
I2C_SCL: R62.1, U14.D1 (SCL), U16.1 (SCL); also elsewhere on the board
I2C_SDA: R61.1, U14.E1 (SDA), U16.6 (SDA); also elsewhere on the board
MUX_ILM: R57.1, U13.10 (ILM)
MUX_OFF: Q5.3 (D), R56.2, U13.4 (OV2), U13.5 (OV1)
MUX_PR1: Q4.3 (D), R53.2, R54.1, U13.6 (PR1)
MUX_SS: C86.1, U13.11 (SS)
PA_APC: C96.1, U15.1 (OUT); also elsewhere on the board
PA_EN: R59.1, U15.3 (EN); also elsewhere on the board
PA_IN: C89.1, C90.1, C91.1, U13.1 (OUT), U13.8 (OUT), U14.A2 (VIN), U14.A3 (VIN)
PA_LX1: L20.1, U14.B2 (LX1), U14.B3 (LX1)
PA_LX2: L20.2, U14.D2 (LX2), U14.D3 (LX2)
PA_PWR_EN: Q5.1 (G), R58.1, U14.A1 (EN); also elsewhere on the board
PA_SRC_SYS: Q4.1 (G), R55.1; also elsewhere on the board
TEMP_ALERT: R60.1, U16.3 (ALERT); also elsewhere on the board
VPA: C92.1, C93.1, C94.1, U14.E2 (VOUT), U14.E3 (VOUT); also elsewhere on the board
VSYS: C88.1, U13.2 (IN2); also elsewhere on the board

Notes on the sheet:
Amplifier power: battery-first supply, buck-boost, control voltage, temperature
Amplifier runs from the battery through a power mux (battery first down to 2.6 V; firmware selects charger SYS when no cell is fitted), then a TPS63810 buck-boost (I2C 0x75): 2.7 V for 1 W, 4.0 V for 3 W.

Schematic: ports.kicad_sch, Ports: drone (JST-GH), GPS add-on (JST-SH), expansion heade…

Parts:
C98: 1uF; C_0402; MPN CL05A105KO5NNNC; DigiKey 1276-1067-1-ND
D10, D11, D12, D13: TPD4E05U06DQAR; USON-10_L2.5-W1.0-P0.50-BL; MPN TPD4E05U06DQAR; DigiKey 296-35765-1-ND
J5: SM06B-GHS-TB(LF)(SN); CONN-TH_SM06B-GHS-TB-LF-SN; MPN SM06B-GHS-TB(LF)(SN); DigiKey 455-1568-1-ND
J6: SM06B-SRSS-TB(LF)(SN); CONN-SMD_SM06B-SRSS-TB-LF-SN; MPN SM06B-SRSS-TB(LF)(SN); DigiKey 455-SM06B-SRSS-TBCT-ND
J7: SM10B-SRSS-TB(LF)(SN); JST_SH_SM10B-SRSS-TB_1x10-1MP_P1.00mm_Horizontal; MPN SM10B-SRSS-TB(LF)(SN); DigiKey 455-SM10B-SRSS-TBCT-ND
LED2: green; LED0603-RD; MPN LTST-C191KGKT; DigiKey 160-1446-1-ND
LED3: blue; LED0603-RD; MPN LTST-C191TBKT; DigiKey 160-1647-1-ND
R63, R64, R65, R66, R67, R68, R69: 470R; R_0402; MPN RC0402FR-07470RL; DigiKey 311-470LRCT-ND
R70: 100k; R_0402; MPN RC0402FR-07100KL; DigiKey 311-100KLRCT-ND
R71: 1M; R_0402; MPN RC0402FR-071ML; DigiKey 311-1.00MLRCT-ND
R72: 1k; R_0402; MPN RC0402FR-071KL; DigiKey 311-1.00KLRCT-ND
R73: 220R; R_0402; MPN RC0402FR-07220RL; DigiKey 311-220LRCT-ND
SW2, SW3: SKRPADE010; KEY-SMD_4P-L4.2-W3.2-P2.20-LS4.6; MPN SKRPADE010; DigiKey 4809-SKRPADE010CT-ND
U17: TPS22916CYFPR; DSBGA-4_TPS22916; MPN TPS22916CYFPR; DigiKey 296-50065-1-ND

Connections:
3V3: J7.2, U17.A2 (VIN); also elsewhere on the board
3V3_GPS: C98.1, J6.1, R70.2, U17.A1 (VOUT)
BTN_USER: SW3.1 (A), SW3.2 (A); also elsewhere on the board
DISP_BL: D13.5 (IO4), J7.10; also elsewhere on the board
DISP_CS: D13.1 (IO1), J7.7; also elsewhere on the board
DISP_DC: D13.2 (IO2), J7.8; also elsewhere on the board
DISP_MOSI: D12.5 (IO4), J7.6; also elsewhere on the board
DISP_RST: D13.4 (IO3), J7.9; also elsewhere on the board
DISP_SCK: D12.4 (IO3), J7.5; also elsewhere on the board
DRN_P2: D10.1 (IO1), J5.2, R63.1
DRN_P3: D10.2 (IO2), J5.3, R64.2
DRN_P4: D10.4 (IO3), J5.4, R65.2
DRN_P5: D10.5 (IO4), J5.5, R66.1
DRONE_5V_CONN: J5.1; also elsewhere on the board
DRONE_CTS: R66.2; also elsewhere on the board
DRONE_RTS: R65.1; also elsewhere on the board
DRONE_RX: R63.2; also elsewhere on the board
DRONE_TX: R64.1; also elsewhere on the board
GND: C98.2, D10.3 (GND), D10.8 (GND), D11.3 (GND), D11.8 (GND), D12.3 (GND), D12.8 (GND), D13.3 (GND), D13.8 (GND), J5.6, J6.6, J7.1, LED2.1 (K), LED3.1 (K), R71.2, SW2.3 (B), SW2.4 (B), SW3.3 (B), SW3.4 (B), U17.B1 (GND); also elsewhere on the board
GPS_EN: R71.1, U17.B2 (ON); also elsewhere on the board
GPS_P2: D11.1 (IO1), J6.2, R67.1
GPS_P3: D11.2 (IO2), J6.3, R68.2
GPS_P4: D11.4 (IO3), J6.4, R69.1
GPS_P5: D11.5 (IO4), J6.5, R70.1
GPS_PPS: R69.2; also elsewhere on the board
GPS_RX: R67.2; also elsewhere on the board
GPS_TX: R68.1; also elsewhere on the board
I2C_SCL: D12.2 (IO2), J7.4; also elsewhere on the board
I2C_SDA: D12.1 (IO1), J7.3; also elsewhere on the board
LED_BLUE: R73.1; also elsewhere on the board
LED_B_A: LED3.2 (A), R73.2
LED_GREEN: R72.1; also elsewhere on the board
LED_G_A: LED2.2 (A), R72.2
NRF_RESET: SW2.1 (A), SW2.2 (A); also elsewhere on the board

Notes on the sheet:
Ports: drone (JST-GH), GPS add-on (JST-SH), expansion header, buttons, LEDs
Drone port wired as Pixhawk TELEM (pins from the autopilot side): 1 5V, 2 TX, 3 RX, 4 CTS, 5 RTS, 6 GND. Series resistors and ESD on every external signal.

Board: 6 copper layers, 70.0 x 25.4 mm, 261 parts (111 on the bottom side), 159 nets.

Other parts of the board:
H1, H2, H3, H4: MountingHole_3.2mm_M3_Pad

Their connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

File products/mesh-radio/production/mesh-radio-bom-jlcpcb.csv:

Comment,Designator,Footprint,LCSC Part #
4.7k,"R44,R61,R62",R_0402,C105871
5.1k,"R1,R2",R_0402,C105872
330R,R32,R_0402,C105875
0R,R43,R_0402,C106231
1k,"R23,R28,R72",R_0402,C106235
220R,"R42,R73",R_0402,C112291
150R,R47,R_0805,C114523
2.2k,"R9,R33",R_0402,C114762
22R,"R10,R40,R41",R_0402,C114765
470R,"R63,R64,R65,R66,R67,R68,R69",R_0402,C114877
green,LED2,LED0603-RD,C125098
red,LED1,LED0603-RD,C125099
SKRPADE010,"SW2,SW3",KEY-SMD_4P-L4.2-W3.2-P2.20-LS4.6,C127488
SM06B-GHS-TB(LF)(SN),J5,CONN-TH_SM06B-GHS-TB-LF-SN,C133065
68R,R48,R_0805,C137498
330k,R50,R_0402,C138006
2.21k,R7,R_0402,C138019
220k,R49,R_0402,C138030
1M,"R5,R13,R19,R29,R30,R36,R38,R55,R56,R58,R71",R_0402,C138033
1.5M,"R11,R15,R17,R21,R37",R_0402,C138034
13k,R24,R_0402,C138057
TPD4E05U06DQAR,"D1,D10,D11,D12,D13",USON-10_L2.5-W1.0-P0.50-BL,C138714
SSM3K56ACT,"Q2,Q4,Q5",SOT-883,C146308
10nF,"C55,C59,C66,C67,C81,C86",C_0402,C15195
100nF,"C12,C13,C14,C22,C23,C24,C28,C41,C42,C44,C85,C94,C97",C_0402,C1525
7.68k,R4,R_0402,C155695
10uF,"C10,C11,C91",C_0805,C15850
SM02B-SRSS-TB(LF)(SN),J2,CONN-SMD_2P-P1.00_SM02B-SRSS-TB-LF-SN,C160402
SM06B-SRSS-TB(LF)(SN),J6,CONN-SMD_SM06B-SRSS-TB-LF-SN,C160405
SM10B-SRSS-TB(LF)(SN),J7,JST_SH_SM10B-SRSS-TB_1x10-1MP_P1.00mm_Horizontal,C160409
1.6pF,C39,C_0402,C161311
47pF,"C47,C54,C64,C70",C_0402,C161322
5.6pF,C49,C_0402,C161329
0.9pF,C38,C_0402,C161350
1.6nH,L13,L_0402,C162539
2.1k,"R14,R20",R_0402,C163473
22.1k,R57,R_0402,C163478
11nH,L19,L_0402,C167465
1.5nH,L5,L_0402,C167468
4.7nH,L10,L_0402,C167480
4.7uF,"C6,C17,C20,C25,C31,C32,C58,C68",C_0603,C1705
2450AT18A0100001E,AE1,ANT-SMD_L3.2-W1.6,C17430588
BQ29700DSER,U5,WSON-6_L1.5-W1.5-P0.50-TL,C183096
SMF33CA,"D5,D6",SOD-123FL,C1851347
TPS63810YFFR,U14,DSBGA-15_L2.2-W1.4-R3-V5-P0.40-BL,C1852139
374k,R54,R_0402,C185423
0.9pF,C78,C_0603,C1865143
SX1262IMLTRT,U9,QFN-24_L4.0-W4.0-P0.50-BL-EP2.6,C191341
8.1nH,L14,L_0908SQ,C19191636
47nH,"L8,L18",L_0402,C192855
10uF,"C16,C18,C19",C_0603,C19702
BQ25185DLHR,U4,WSON-10_L2.2-W2.0-P0.40-BL-EP_TI_DLH0010A,C19725033
3.2nH,L16,L_0805,C2043110
3.6nH,"L15,L17",L_0805,C2045110
TPS62840YBGR,U7,DSBGA-6_L1.4-W1.0-R2-C3-P0.40-BL,C2071139
4.7V,D7,SOD-323FL,C209560
68R,R46,R_0805,C2114866
MAX17608ATC+T,"U2,U3",TDFN-12_L3.0-W3.0-P0.50-BL-EP,C2155884
47uF,"C92,C93",C_1206,C2167997
5.6pF,C73,C_0603,C2171689
3.0pF,C76,C_0603,C2178931
2.2pF,"C75,C77",C_0603,C2179335
15pF,C71,C_0603,C2181572
JS202011JCQN,SW1,SW_DPDT_CK_JS202011JCQN,C221665
10k NTC,TH1,R_0402,C237326
12pF,"C33,C34",C_0402,C26406
SKY13330-397LF,U11,QFN-12_L2.0-W2.0-P0.50-BL-EP0.8,C2654715
TPS22916CYFPR,U17,DSBGA-4_TPS22916,C2680319
562k,R53,R_0402,C273337
32.768kHz,Y2,ABS07,C276424
TLV75528PDQNR,U15,X2SON-4_L1.0-W1.0-P0.65-TL-EP,C2865384
CSD25310Q2T,Q1,WSON-6_DQK_CSD25310Q2,C2871649
1uF,"C21,C26,C40,C95,C96,C98",C_0402,C29266
S2B-PH-SM4-TB(LF)(SN),J3,CONN-SMD_P2.00_S2B-PH-SM4-TB-LF-SN,C295747
1uF,"C9,C15,C87,C88",C_0603,C29936
47nF,"C27,C46",C_0402,C307434
RB060MM-30,"D4,D8",SOD-123FL,C308720
1R,R8,R_0805,C313850
TPS22950YBHR,U6,DSBGA-6_L1.2-W0.8-R2-C3-P0.40-BL,C3230039
287k,R6,R_0402,C327358
267k,"R12,R18,R39",R_0402,C327360
2.2uH,L1,L_0806,C337891
NRF52840-QIAA-F-R7,U8,AQFN-73_L7.0-W7.0-P0.50-BL-EP4.8,C3606858
TPS259470ARPWR,U1,VQFN-10_L2.0-W2.0-P0.45-TL,C3662799
TMP1075NDRLR,U16,SOT-563_L1.6-W1.2-P0.50-LS1.6-BR,C3663690
15uH,L7,L_0805,C383402
1.5pF,C79,C_0603,C3869699
49.9R,R51,R_0805,C4088942
39pF,C50,C_0402,C426038
1.15k,R35,R_0402,C477191
470nF,C43,C_0402,C480644
TPS2121RUXR,U13,VQFN-12_TPS2121RUX,C485916
LFCG-1000+,FL1,FILTER-SMD_8P-L2.0-W1.3-BL_LFCG-XX,C4989745
12401610E4#2A,J1,USB-C-SMD_TYPE-C-24P,C5119948
4.7uF,C5,C_1206,C51205
32MHz,Y1,CRYSTAL-SMD_4P-L2.0-W1.6-BL_CXAN-211,C5189005
QPA9510TR7,U10,QFN-16_3x3_QPA9510,C52059849
TVS2200DRVR,D2,WSON-6_L2.0-W2.0-P0.65-BL-EP,C523793
"SSM10N954L,EFF",Q3,CSP-10L_SSM10N954L,C5274420
BGA7L1BN6E6327XTSA1,U12,TSNP-6_L1.1-W0.7-P0.40-BL,C534173
ECS-TXO-20CSMV4-320-AP-TR,Y3,OSC-SMD_4P-L2.0-W1.6-BL,C54284784
10k,"R26,R27,R45",R_0402,C60490
100k,"R16,R22,R25,R31,R52,R59,R60,R70,R74",R_0402,C60491
BAT6804WH6327XTSA1,"D9,D14",SOT-323,C6129734
11nH,L12,L_0603,C701196
2.5nH,L9,L_0402,C703121
0.47uH,L20,L_1008,C703140
10R@100MHz,"FB1,FB2",L_0402,C76882
1.5pF,C65,C_0402,C76900
1.8pF,"C51,C53",C_0402,C76902
1nF,"C2,C3,C56,C60,C69,C82,C83,C84,C99",C_0402,C76947
100pF,"C1,C29,C80",C_0402,C77177
5.6V,D3,SOD-323FL,C79630
15mR,R34,R_1206,C844911
10pF,"C35,C36,C45",C_0402,C85874
820pF,C30,C_0402,C85943
22uF,"C89,C90",C_0805,C86817
49.9R,R75,R_0402,C87044
10uH,L2,L_0805,C88173
47pF,C74,C_0603,C882552
10pF,C72,C_0603,C882554
U.FL-R-SMT-1(80),J4,RF-SMD_FRF05002-JSS103M,C88374
15pF,C61,C_0402,C88877
27pF,"C57,C62,C63",C_0402,C88884
2.4pF,C52,C_0402,C88888
3.0pF,C48,C_0402,C88891
0.8pF,C37,C_0402,C88902
1uF,"C4,C7,C8",C_0603,C92848
20k,R3,R_0402,C93942
15nH,"L3,L11",L_0402,C94079
2.7nH,L6,L_0402,C98058
3.9nH,L4,L_0402,C98063
blue,LED3,LED0603-RD,C99290
