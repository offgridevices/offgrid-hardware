# Repository offgridevices/offgrid-hardware (continued)

## KiCad design products/smokebreak/smokebreak.kicad_pcb

Board: 6 copper layers, 91.6 x 50.6 mm, 208 parts (1 on the bottom side), 123 nets.

Parts:
BZ1: MLT-8530; BUZ-SMD_4P-L8.5-W8.5-P8.50-BR
C1, C2, C26: 2u2F 100V; C_1210_3225Metric
C3, C4, C14, C27: 100nF 100V; C_0603_1608Metric
C5, C32, C41, C49: 1uF 25V; C_0603_1608Metric
C6, C8, C16: 1nF 50V; C_0402_1005Metric
C7, C10, C11, C12, C13, C15, C17, C18, C19, C20, C21, C22, C23, C34, C35, C36, C38, C42, C43, C44, C45, C46, C47, C48, C55, C56: 100nF 16V; C_0402_1005Metric
C9, C39, C40: 10nF 50V; C_0402_1005Metric
C28: 3n3F 50V; C_0402_1005Metric
C29: 2n2F 50V; C_0402_1005Metric
C30, C31: 10uF 10V; C_0805_2012Metric
C33, C37: 4u7F 10V; C_0603_1608Metric
C50, C51, C52, C53: 4u7F 100V; C_1210_3225Metric
C54: 22nF 50V; C_0402_1005Metric
C57: 56pF 50V; C_0402_1005Metric
D1: SMBJ64CA; SMB_L4.6-W3.6-LS5.3-BI
D2: 10 V; SOD-123_L2.7-W1.6-LS3.7-RD
D3: SS2H10; D_SMB
D4, D14, D16: BAT46WJ; SOD-323F_L2.0-W1.6-LS2.5-RD
D5: BAT54S; SOT-23-3_L3.0-W1.7-P0.95-LS2.9-BR
D6, D7, D8, D9, D10, D11, D15, D17, D19: 1N4148WS; SOD-323_L1.8-W1.3-LS2.5-RD
D18: 15 V; SOD-123_L2.7-W1.6-LS3.7-RD
D20: 12 V; SOD-123_L2.7-W1.6-LS3.7-RD
F1: 40 A 80 V; Fuse_Eaton_2822HC
H1, H2, H3: M3; MountingHole_M3_Washer
J1: XT60 male; CONN-TH_XT60PW-M
J2: XT30 male; CONN-TH_XT30PW-M
J3: XT60 female lead; WirePads_12AWG_NS
J4: XT30 female lead; WirePads_16AWG_NS
J5: JST-XH 6S; JST_XH_B7B-XH-A_1x07_P2.50mm_Vertical_Tight
J6: SWD; SWD_Pads_1x5_P2.54
J7: ER-TFT2.25-1 FPC; Hirose_FH12-8S-0.5SH_1x08-1MP_P0.50mm_Horizontal
J8: USB-C; USB-C_SMD-TYPE-C-31-M-12_1
J9: JST-XH 5S; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical_Tight
J10: JST-XH 4S; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical_Tight
J11: JST-XH 3S; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical_Tight
J12: JST-XH 2S; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical_Tight
L1: 47 uH; L_Changjiang_FNR6045S
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12: WS2812B-2020; LED-SMD_4P-L2.2-W2.0-P1.00_WS2815C-2020-4P
Q1: input FET; PG-TDSON-8_L5.9-W5.1-P1.27-LS6.1-BL
Q2: output FET; PG-TDSON-8_L5.9-W5.1-P1.27-LS6.1-BL
Q3: SUD50P10-43L; TO-252-3_L6.5-W5.8-P4.58-BR
Q4: MMBTA42; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR
Q5, Q10: BC817; SOT-23-3_L2.9-W1.6-P1.90-LS2.8-BR
Q6, Q7: MMBT5401; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR
Q8, Q12: 2N7002; SOT-23_L2.9-W1.3-P1.90-LS2.4-BR
Q9: AO3401A; SOT-23_L2.9-W1.3-P1.90-LS2.4-BR
Q11: BSC070N10LS5; PG-TDSON-8_L5.9-W5.1-P1.27-LS6.1-BL
R1: 10 Ohm; R_0603_1608Metric
R2, R4, R30, R33: 1 M; R_0603_1608Metric
R3: 470 k; R_0402_1005Metric
R5: 19.6 k; R_0402_1005Metric
R6, R10, R13, R18, R23, R24, R26, R27, R37, R39, R41, R43, R45, R47, R52, R60, R64, R65, R79, R80: 100 k; R_0402_1005Metric
R7: 1 M; R_0402_1005Metric
R8, R11, R12, R21, R22, R25, R35, R66: 10 k; R_0402_1005Metric
R9: 40.2 k; R_0402_1005Metric
R14, R15: 10 Ohm; R_0402_1005Metric
R16: 100 Ohm; R_0402_1005Metric
R17, R54, R55, R61, R69, R71: 1 k; R_0402_1005Metric
R19, R32: 100 k; R_0603_1608Metric
R20: 47 k; R_0805_2012Metric
R28: 1 k; R_0603_1608Metric
R29: 100 Ohm; R_0805_2012Metric
R31, R34: 52.3 k; R_0402_1005Metric
R36: 47 k; R_0402_1005Metric
R38: 200 k; R_0402_1005Metric
R40: 357 k; R_0402_1005Metric
R42: 499 k; R_0402_1005Metric
R44: 649 k; R_0402_1005Metric
R46: 787 k; R_0402_1005Metric
R53: 10 Ohm; R_0805_2012Metric
R56: 33 Ohm; R_1206_3216Metric
R62, R63: 5.1 k; R_0402_1005Metric
R67: 0.33 Ohm; R_1206_3216Metric
R68: 0.47 Ohm; R_0805_2012Metric
R70: 49.9 k; R_0402_1005Metric
R72: 4.7 k; R_0402_1005Metric
R73: 820 Ohm; R_0402_1005Metric
R74: 4.7 M; R_0603_1608Metric
R75: 10 Ohm; R_1206_3216Metric
R76: 30.9 k; R_0402_1005Metric
R77: 453 k; R_0402_1005Metric
R78: 143 k; R_0402_1005Metric
RS1: 1 mOhm; RES-SMD_4P-L3.8-W3.1
RT1, RT2: 10 k NTC; R0402
R_PRE, R_PRE2: 3.9 Ohm 20 W; TO-263-2
SW1: ON-OFF-(ON); SW_Toggle_SPDT_P4.70mm_THT
SW2: Limit -; KEY-SMD_B3U-1000PM
SW3: Limit +; KEY-SMD_B3U-1000PM
U1: TPS48000; VSSOP-19_L5.1-W3.0-P0.50-LS4.9
U2: INA181A2; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL
U3: LM5164DDAR; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm
U4: TLV75533; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U5: STM32G0B1RBT6; LQFP-64_L10.0-W10.0-P0.50-LS12.0-BL
U6: DRV5032FA; SOT-23-3_L2.9-W1.3-P0.95-LS2.4-BR
U7: 74LVC1G11; SC-88-6_L2.0-W1.3-P0.65-LS2.1-BL
U8, U12: LMV331; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U9: SN74LVC1G74; SSOP-8_L2.0-W2.3-P0.50-LS3.1-BR
U10: SN74AHCT1G125; SOT-23-5
U11: USBLC6-2SC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL

Connections:
+3V3: C7.1, C10.1, C11.1, C12.1, C13.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C41.1, C56.1, D5.2, J6.1, J7.7, Q6.2, Q7.2, R8.1, R11.2, R12.2, R25.1, R26.2, R27.2, R35.1, R54.2, R55.2, R66.2, R70.1, U2.6, U4.5, U5.6, U5.7, U5.8, U6.1, U7.5, U8.5, U9.2, U9.7, U9.8, U12.5
+5V: BZ1.1, C28.2, C30.1, C31.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, D16.1, D17.1, L1.2, LED1.4, LED2.4, LED3.4, LED4.4, LED5.4, LED6.4, LED7.4, LED8.4, LED9.4, LED10.4, LED11.4, LED12.4, Q9.2, R77.1, R80.1, U4.1, U4.3, U10.5
ARM_CLK: U5.60, U9.1
AUX: D6.1, D7.1, D8.1, D9.1, D10.1, D11.1, D14.1, D15.1, R53.1
AUX_F: C26.1, C27.1, R53.2, U3.2, U3.3
BAL1: J5.1, J9.1, J10.1, J11.1, J12.1, R75.1
BAL2: D6.2, J5.2, J9.2, J10.2, J11.2, J12.2, R36.1
BAL2_ADC: C18.1, R36.2, R37.1, U5.24
BAL3: D7.2, J5.3, J9.3, J10.3, J11.3, J12.3, R38.1
BAL3_ADC: C19.1, R38.2, R39.1, U5.27
BAL4: D8.2, J5.4, J9.4, J10.4, J11.4, R40.1
BAL4_ADC: C20.1, R40.2, R41.1, U5.28
BAL5: D9.2, J5.5, J9.5, J10.5, R42.1
BAL5_ADC: C21.1, R42.2, R43.1, U5.29
BAL6: D10.2, J5.6, J9.6, R44.1
BAL6_ADC: C22.1, R44.2, R45.1, U5.30
BAL7: D11.2, J5.7, R46.1
BAL7_ADC: C23.1, R46.2, R47.1, U5.31
BATT_NEG: J1.1, J2.1, Q11.5, Q11.6, Q11.7, Q11.8
BL_G: Q9.1, Q12.3, R80.2
BL_SW: Q9.3, R56.1
BTN_MINUS: SW2.1, U5.15
BTN_PLUS: SW3.1, U5.16
BUCK_BOOT: C29.1, U3.7
BUCK_FB: C57.2, R77.2, R78.1, U3.5
BUCK_RA: C28.1, C57.1, R79.2
BUCK_RON: R76.1, U3.4
BUCK_SW: C29.2, L1.1, R79.1, U3.8
BUZZER: R61.1, U5.36
BZ_B: Q10.1, R61.2
BZ_N: BZ1.2, D17.2, Q10.3
CDVDT: C54.1, R69.2
DIV_EN: Q8.1, R52.1, U5.53
DIV_GND: C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, Q8.3, R37.2, R39.2, R41.2, R43.2, R45.2, R47.2
DRONE_NEG: C14.2, C52.2, C53.2, J3.2, J4.2, RS1.1
GATE: D18.1, Q1.4, Q2.4, R6.2, R7.1, R69.1, U1.14
GND: C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C15.2, C16.2, C17.2, C26.2, C27.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C54.2, C55.2, C56.2, D1.2, D5.1, D20.2, J6.5, J7.2, J7.MP, J8.1, J8.2, J8.3, J8.4, J8.A1B12, J8.B1A12, LED1.2, LED2.2, LED3.2, LED4.2, LED5.2, LED6.2, LED7.2, LED8.2, LED9.2, LED10.2, LED11.2, LED12.2, Q5.2, Q8.2, Q10.2, Q11.1, Q11.2, Q11.3, Q12.2, R3.2, R5.2, R9.2, R10.2, R13.2, R18.2, R23.2, R24.2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
GUARD_OPEN: R22.1, U5.3, U6.2, U7.3
HS_REF: C55.1, R70.2, R71.1, U12.1
INA_N: C6.2, R15.2, U2.4
INA_P: C6.1, R14.2, U2.3
I_ADC: C8.1, R16.2, U5.20
I_SENSE: R16.1, U2.1, U8.3
LATCH_OK: U7.6, U9.5
LCD_BL: Q12.1, R60.1, U5.48
LCD_CS: J7.8, U5.34
LCD_DC: J7.4, U5.38
LCD_LEDA: J7.1, R56.2
LCD_RST: J7.3, U5.39
LCD_SCK: J7.6, U5.33
LCD_SDA: J7.5, U5.35
LED_D1: LED1.1, LED2.3
LED_D2: LED2.1, LED3.3
LED_D3: LED3.1, LED4.3
LED_D4: LED4.1, LED5.3
LED_D5: LED5.1, LED6.3
LED_D6: LED6.1, LED7.3
LED_D7: LED7.1, LED8.3
LED_D8: LED8.1, LED9.3
LED_D9: LED9.1, LED10.3
LED_D10: LED10.1, LED11.3
LED_D11: LED11.1, LED12.3
LED_DATA: U5.59, U10.2
LED_DIN0: LED1.3, U10.4
MCU_EN: R18.1, U5.58, U7.1
NRST: C38.1, J6.3, U5.12
NTC_FET: R35.2, RT1.1, U5.22
NTC_PRE: R25.2, RT2.1, U5.23
PEAK_DAC: R17.1, U5.21
PEAK_OK: R66.1, U5.61, U8.4, U9.6, U12.4
PEAK_REF: C9.1, R17.2, U8.1
PRE_B1: Q4.1, R21.2, R23.1
PRE_B2: Q5.1, R22.2, R24.1
PRE_D: D3.2, Q3.2
PRE_G: D2.2, Q3.1, R19.2, R20.1
PRE_K: D3.1, R_PRE.1
PRE_M: R_PRE.3, R_PRE2.1
PRE_MID: Q4.2, Q5.3
PRE_ON: R21.1, U5.50
PRE_PULL: D19.1, Q4.3
PRE_R: D19.2, R20.2
PROBE: D4.2, R28.2, R29.2
PROBE_1K_N: R72.1, U5.51
PROBE_100_N: R73.1, U5.52
PROBE_A: Q6.3, R28.1
PROBE_B: Q7.3, R29.1
PROBE_BB1: Q6.1, R26.1, R72.2
PROBE_BB2: Q7.1, R27.1, R73.2
Q11_G: D20.1, Q11.4, R74.2
SNS_DRN: R14.1, RS1.2, U1.18, U12.3
SNS_GND: R15.1, RS1.3, U1.17
SRC: C5.2, D18.2, Q1.1, Q1.2, Q1.3, Q2.1, Q2.2, Q2.3, R7.2, U1.13
SWCLK: J6.4, U5.46
SWDIO: J6.2, U5.45
TOG_BIND: C40.1, R55.1, SW1.1, U5.14
TOG_ON: C39.1, R54.1, SW1.3, U5.13
TPS_BST: C5.1, U1.12
TPS_CSSEL: R8.2, U1.7
TPS_EN: R2.2, R3.1, U1.1
TPS_FLT: R11.1, U1.5, U5.64
TPS_FLTGD: R12.1, U1.4, U5.1
TPS_INP: R13.1, U1.3, U7.4
TPS_ISCP: R9.1, U1.8
TPS_OV: R4.2, R5.1, U1.2
TPS_PU: R6.1, U1.15
TPS_SCPTEST: R10.1, U1.10, U5.2
TPS_VS: C4.1, R1.2, U1.20
USB_CC1: J8.A5, R62.1
USB_CC2: J8.B5, R63.1
USB_DM: U5.43, U11.4
USB_DM_C: J8.A7, J8.B7, U11.3
USB_DP: U5.44, U11.6
USB_DP_C: J8.A6, J8.B6, U11.1
VBAT: F1.1, J1.2, J2.2
VBUS: C49.1, D16.2, J8.A4B9, J8.B4A9, R64.1, U11.5
VBUS_SENSE: R64.2, R65.1, U5.26
VIN: C1.1, C2.1, C3.1, D1.1, D2.1, D14.2, F1.2, Q1.5, Q1.6, Q1.7, Q1.8, Q3.3, R1.1, R2.1, R4.1, R19.1, R33.1, R67.1, R74.1
VIN_DAMP: C50.1, C51.1, R67.2
VIN_SENSE: C17.1, R33.2, R34.1, U5.17
VOUT: C14.1, D4.1, D15.2, J3.1, J4.1, Q2.5, Q2.6, Q2.7, Q2.8, R30.1, R32.1, R68.1, R_PRE2.3
VOUT_LO: C16.1, D5.3, R32.2, U5.19
VOUT_SENSE: C15.1, R30.2, R31.1, U5.18
VOUT_SNUB: C52.1, C53.1, R68.2

## KiCad design products/print-hub/print-hub.kicad_pcb

Board: 4 copper layers, 86.0 x 50.0 mm, 137 parts (0 on the bottom side), 78 nets.

Parts:
C1: 1uF; C_0603_1608Metric
C2, C3: 10uF; C_1206_3216Metric
C4, C5, C7, C13, C14, C19, C21, C101, C103, C104, C106, C201, C203, C204, C206, C301, C303, C304, C306, C401, C403, C404, C406, C501, C503, C504, C506: 100nF; C_0402_1005Metric
C6, C20: 1uF; C_0402_1005Metric
C8: 22pF; C_0402_1005Metric
C9, C10, C11, C12, C102, C105, C202, C205, C302, C305, C402, C405, C502, C505: 22uF; C_1206_3216Metric
C15, C16, C17: 10uF; C_0603_1608Metric
C18: 22uF; C_0603_1608Metric
D1: SMAJ15A; SMA_L4.3-W2.6-LS5.0-RD
D2, D3: B5819W; SOD-123_L2.7-W1.6-LS3.7-RD-1
H1, H2: HOLE; MOUNT_M3
J1, J2: USB-C; USB-C_SMD-TYPE-C-31-M-12_1
J101, J201, J301, J401, J501: USB-A; USB-A-TH__USB-AF-90
L1: 2.2uH; IND-SMD_L7.0-W6.6
LED1, LED101, LED201, LED301, LED401, LED501: WS2812B-2020; LED-SMD_4P-L2.2-W2.0-P1.00_WS2815C-2020-4P
R1, R17, R18: 5.1k; R_0402_1005Metric
R2, R11, R105, R205, R305, R405, R505: 1k; R_0402_1005Metric
R3, R9, R12, R19, R20, R103, R203, R303, R403, R503: 10k; R_0402_1005Metric
R4: 470R; R_0402_1005Metric
R5, R6: 4.7k; R_0402_1005Metric
R7, R13, R15, R16, R102, R202, R302, R402, R502: 100k; R_0402_1005Metric
R8: 10k NTC; R_0402_1005Metric
R10: 75k; R_0402_1005Metric
R14: 15k; R_0402_1005Metric
R21: 100R; R_0402_1005Metric
R101, R201, R301, R401, R501: 47k; R_0402_1005Metric
R104, R204, R304, R404, R504: 20mR; R_1206_3216Metric
SW1, SW2: button; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL_H1.5
TP1, TP2, TP3, TP4: TP; PAD_TP
U1: HUSB238; DFN-10_L3.0-W3.0-P0.50-BL-EP2.5
U2: SY8368A; QFN-12_L3.0-W3.0-P0.45-TL-EP
U3: USBLC6-2SC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL
U4: AP2112K-3.3; SOT-25-5_L2.9-W1.6-P0.95-LS2.8-BL
U5: ESP32-S3-WROOM-1-N8; WIFIM-SMD_ESP32-S3-WROOM-1-N8
U101, U201, U301, U401, U501: TPS25200; WSON-6_L2.0-W2.0-P0.65-TL-EP
U102, U202, U302, U402, U502: INA180A2; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL

Connections:
+3V3: C17.1, C18.1, C19.1, C103.1, C203.1, C303.1, C403.1, C503.1, R5.2, R6.2, R9.2, R19.2, R20.2, R103.2, R203.2, R303.2, R403.2, R503.2, U4.5, U5.2, U102.5, U202.5, U302.5, U402.5, U502.5
BOOT: R20.1, SW2.1, U5.27
BUCK_BS: C5.1, U2.7
BUCK_EN: R7.2, U2.12
BUCK_FB: C8.2, R11.2, R12.1, U2.9
BUCK_FB2: R10.2, R11.1
BUCK_LX: C5.2, L1.1, U2.2
BUCK_VCC: C6.1, U2.8
CC1_DATA: J2.A5, R17.1
CC1_IN: J1.A5, U1.4
CC2_DATA: J2.B5, R18.1
CC2_IN: J1.B5, U1.5
DCP1: J101.2, J101.3
DCP2: J201.2, J201.3
DCP3: J301.2, J301.3
DCP4: J401.2, J401.3
DCP5: J501.2, J501.3
EN1: R102.1, U5.23, U101.4
EN2: R202.1, U5.18, U201.4
EN3: R302.1, U5.19, U301.4
EN4: R402.1, U5.20, U401.4
EN5: R502.1, U5.21, U501.4
ESP_EN: C20.1, R19.1, SW1.1, U5.3
FLT1: R103.1, U5.22, U101.3
FLT2: R203.1, U5.8, U201.3
FLT3: R303.1, U5.9, U301.3
FLT4: R403.1, U5.10, U401.3
FLT5: R503.1, U5.11, U501.3
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, D1.2, J1.1, J1.2, J1.3, J1.4, J1.A1B12, J1.B1A12, J2.1, J2.2, J2.3, J2.4, J2.A1B12, J2.B1A12, J101.4, J101.SH1, J101.SH2, J201.4, J201.SH1, J201.SH2, J301.4, J301.SH1, J301.SH2, J401.4, J401.SH1, J401.SH2, J501.4, J501.SH1, J501.SH2, LED1.2, LED101.2, LED201.2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
ILIM1: R101.1, U101.2
ILIM2: R201.1, U201.2
ILIM3: R301.1, U301.2
ILIM4: R401.1, U401.2
ILIM5: R501.1, U501.2
IS1: C104.1, R105.2, U5.39
IS2: C204.1, R205.2, U5.38
IS3: C304.1, R305.2, U5.4
IS4: C404.1, R405.2, U5.5
IS5: C504.1, R505.2, U5.6
ISA1: R105.1, U102.1
ISA2: R205.1, U202.1
ISA3: R305.1, U302.1
ISA4: R405.1, U402.1
ISA5: R505.1, U502.1
LED_C1: LED101.3, LED201.1
LED_C2: LED201.3, LED301.1
LED_C3: LED301.3, LED401.1
LED_C4: LED401.3, LED501.1
LED_C5: LED1.1, LED501.3
LED_D0: LED1.3, R21.2
LED_DIN0: R21.1, U5.31
NTC: C7.1, R8.1, R9.1, U5.17
PD_ISET: R3.1, U1.9
PD_ISET2: R3.2, R4.1
PD_VSET: R1.1, U1.8
PD_VSET2: R1.2, R2.1
PORT1_SW: R104.1, U101.1, U102.3
PORT2_SW: R204.1, U201.1, U202.3
PORT3_SW: R304.1, U301.1, U302.3
PORT4_SW: R404.1, U401.1, U402.3
PORT5_SW: R504.1, U501.1, U502.3
RAIL_SENSE: C14.1, R15.2, R16.1, U5.12
RXD0: TP2.1, U5.36
SCL: R6.1, U1.7, U5.33
SDA: R5.1, U1.6, U5.32
TXD0: TP1.1, U5.37
USB_DN: J2.A7, J2.B7, U3.1, U3.6, U5.13
USB_DP: J2.A6, J2.B6, U3.3, U3.4, U5.14
VBUS1: C105.1, J101.1, R104.2, U102.4
VBUS2: C205.1, J201.1, R204.2, U202.4
VBUS3: C305.1, J301.1, R304.2, U302.4
VBUS4: C405.1, J401.1, R404.2, U402.4
VBUS5: C505.1, J501.1, R504.2, U502.4
VBUS_DATA: C15.1, D3.2, J2.A4B9, J2.B4A9, U3.5
VBUS_IN: C1.1, C2.1, C3.1, C4.1, D1.1, J1.A4B9, J1.B4A9, R7.1, R13.1, U1.1, U2.4, U2.5, U2.6
VIN_SENSE: C13.1, R13.2, R14.1, U5.7
VLOGIC: C16.1, C21.1, C106.1, C206.1, C306.1, C406.1, C506.1, D2.1, D3.1, LED1.4, LED101.4, LED201.4, LED301.4, LED401.4, LED501.4, U4.1, U4.3
VRAIL: C8.1, C9.1, C10.1, C11.1, C12.1, C101.1, C102.1, C201.1, C202.1, C301.1, C302.1, C401.1, C402.1, C501.1, C502.1, D2.2, L1.2, R10.1, R15.1, TP4.1, U101.6, U201.6, U301.6, U401.6, U501.6

## KiCad design products/layercam/layercam-pro/layercam-pro.kicad_pcb

File products/layercam/README.md:

# LayerCam

Cameras for the inside of a Prusa CORE One, in Prusa's own Buddy3D camera
case: they feed Prusa Connect, see the bed in daylight and in infrared, and
make a per-layer timelapse that they upload to a NAS or S3. Each variant is
its own product, with its own folder, revision, tests and CI job.

| Variant | What it is | Revision | Status |
|---|---|---|---|
| [LayerCam](layercam/) | Three boards in the case (main, LED ring, USB-C), a camera module and lens bought separately, a stick-on heatsink | 1.0 | designed, not yet built |
| [LayerCam Pro](layercam-pro/) | LayerCam's camera on **one** board, sensor soldered on, no board-to-board cables; ESP32-C6 Wi-Fi with an external antenna | 1.0 | designed, not yet built |

## How they differ

| | LayerCam | LayerCam Pro |
|---|---|---|
| Boards | three, joined by cables | one |
| Main chip | RV1106G3 | RV1106G3, so LayerCam's software carries over |
| Camera | module and lens bought separately | sensor on the board |

Each README has the details, how to order it, and its test record.
How revisions work: [`docs/versioning.md`](../../docs/versioning.md).

Board: 6 copper layers, 65.3 x 57.8 mm, 189 parts (86 on the bottom side), 100 nets.

Parts:
C1, C2, C5, C8, C9, C10, C21, C33, C34, C35, C40, C41, C53, C87, C89: 10uF; C_0603_1608Metric
C3, C4, C24, C25, C26, C27, C28, C29, C36, C37, C38, C42, C43, C44, C46, C47, C48, C49, C50, C51, C52, C54, C56, C59, C60, C68, C71, C72, C76, C77, C79, C81, C82, C86, C88, C90: 100nF; C_0402_1005Metric
C6: 6.8pF; C_0402_1005Metric
C7, C15, C16, C18, C20, C22, C23, C70: 22uF; C_0603_1608Metric
C11, C30, C31, C32, C39, C45, C55, C57, C61, C69, C73, C74, C75, C78, C85: 1uF; C_0402_1005Metric
C12: 330nF; C_0402_1005Metric
C13: 470nF; C_0402_1005Metric
C14, C17, C19: 220pF; C_0402_1005Metric
C58, C80: 4.7uF; C_0402_1005Metric
C62, C63, C64, C65: 18pF; C_0402_1005Metric
C66: 10nF; C_0402_1005Metric
C67: 1nF; C_0402_1005Metric
C83, C84: 2.2uF; C_0402_1005Metric
D1: SMF6.0CA; SOD-123FL_L2.8-W1.8-LS3.7-BI
D2, D3, D4, D5, D6, D7: 850nm; LED_PLCC2_VSMY3850
H1, H2, H3, H4: HOLE_M2; MOUNT_M2
H5, H6: HOLE_M1V6; MOUNT_M1V6
J1: USB-C; USB-C_SMD-TYPE-C-31-M-12_1
J3: IR-cut; CONN-SMD_532610271
L1, L5: 2.2uH; IND-SMD_L2.5-W2.0
L2, L3, L4: 1.5uH; IND-SMD_L2.5-W2.0
L6, L7, L8: 120R@100MHz; L_0402_1005Metric
LED1: green; LED0603-RD
Q1: AO3400A; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR
Q2: TEMT6000; SENSORS-SMD_TEMT6000X01
R1, R23, R27, R28, R30, R31, R33, R34, R35, R36, R37: 10k; R_0402_1005Metric
R2: 18k; R_0402_1005Metric
R3: 51k; R_0402_1005Metric
R4, R5, R7, R10, R12, R13, R29, R43, R44, R46: 100k; R_0402_1005Metric
R6, R11: 200k; R_0402_1005Metric
R8, R14: 22.6k; R_0402_1005Metric
R9: 127k; R_0402_1005Metric
R15, R16, R39: 1R; R_0402_1005Metric
R17: 6.2k; R_0402_1005Metric
R18: 240R; R_0402_1005Metric
R19, R24, R45: 100R; R_0402_1005Metric
R20, R26, R32, R40: 22R; R_0402_1005Metric
R21: 1M; R_0402_1005Metric
R22, R25, R38, R47: 1k; R_0402_1005Metric
R41, R42: 4.7k; R_0402_1005Metric
R48: 22k; R_0402_1005Metric
R49, R50: 5.1k; R_0402_1005Metric
R90, R91, R92: 47R; R_1206_3216Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TP; PAD_TP
U1: RV1106G3; QFN-128_L12.3-W12.3-P0.35-TL-EP7.0-1
U2, U4: TLV62569; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U3: EA3036C; WQFN-20_L3.0-W3.0-P0.40-BL-EP
U5: W25N02KV; WSON-8_L8.0-W6.0-P1.27-TL-EP-1
U6: ESP32-C6-MINI-1U-H4; WIFIM-SMD_61P-L13.2-W12.5-P0.80
U7: DRV8210P; WSON-8_L2.0-W2.0-P0.50-TL-EP
U8: SC4336H; CSP-35_L5.7-W3.7-P0.64-R5-C7-S0.58-TL
U9: 2.8V; WSON-6_L2.0-W2.0-P0.65-BL-EP
U10: USBLC6-2SC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL
Y1: 24MHz; CRYSTAL-SMD_4P-L3.2-W2.5-BL
Y2: 32.768kHz; FC-135R_L3.2-W1.5

Connections:
ALS: C88.1, Q2.1, Q2.2, R48.1, U1.22
ALS_VCC: Q2.3, R47.2
BOOT_KEY: C67.1, R23.1, R24.1, U1.23
BOOT_SW: R24.2, TP5.1
CAM_AVDD: C74.1, C75.1, C76.1, C77.1, U8.B1, U8.B7, U9.1
CAM_DOVDD: C78.1, C79.1, R39.2, U8.C2, U8.C3
CAM_DVDD: C80.1, C81.1, C82.1, U8.B4, U8.B6, U8.C1, U8.E4
CAM_MCLK: R40.2, U8.A3
CAM_MCLK_SOC: R40.1, U1.2
CAM_PWDN: R44.1, U1.4, U8.C6
CAM_RST: R43.1, U1.3, U8.A6
CAM_SCL: R41.1, U1.5, U8.A5
CAM_SDA: R42.1, U1.7, U8.A4
CAM_VREFN: C83.1, U8.E7
CAM_VREFN2: C84.1, U8.D7
CC1: J1.A5, R49.1
CC2: J1.B5, R50.1
CODEC_VCM: C58.1, U1.30
CSI_CKN: U1.125, U8.D4
CSI_CKP: U1.126, U8.C4
CSI_D0N: U1.127, U8.D5
CSI_D0P: U1.128, U8.E5
CSI_D1N: U1.123, U8.D2
CSI_D1P: U1.124, U8.D3
DBG_RX: TP2.1, U1.80
DBG_TX: TP1.1, U1.79
DRAM_ZQ: R18.1, U1.52
EN_3V3: C13.1, R6.2, U3.9
EN_MID: C12.1, R5.2, U3.8, U3.18
ETH_EXTR: R17.1, U1.102
FB_0V9: C6.2, R3.2, R4.1, U2.5
FB_1V8: C19.2, R11.2, R12.1, U3.2
FB_3V3: C14.2, R7.2, R8.1, U3.14
FB_DDR: C17.2, R9.2, R10.1, U3.3
FB_WIFI: R13.2, R14.1, U4.5
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C15.2, C16.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2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
IRCUT_1: J3.1, U7.2
IRCUT_2: J3.2, U7.3
IRCUT_A: U1.72, U7.6
IRCUT_B: U1.73, U7.5
IR_GATE: Q1.1, R45.2, R46.1
IR_PWM: R45.1, U1.77
LED_K: D3.2, D5.2, D7.2, Q1.3
LED_STATUS: R25.1, U1.95
LED_STATUS_A: LED1.2, R25.2
LX_1V8: L4.1, U3.20
LX_3V3: L2.1, U3.11
LX_DDR: L3.1, U3.6
NAND_CLK: R26.2, U5.6
NAND_CLK_SOC: R26.1, U1.48
NAND_CS: U1.47, U5.1
NAND_IO0: U1.41, U5.5
NAND_IO1: U1.42, U5.2
NAND_IO2: R27.1, U1.44, U5.3
NAND_IO3: R28.1, U1.39, U5.7
NPOR: C66.1, R22.1, U1.66
RTC_XIN: C64.1, U1.21, Y2.1
RTC_XOUT: C65.1, U1.20, Y2.2
SD_CLK: R32.2, U6.25
SD_CLK_SOC: R32.1, U1.15
SD_CMD: R33.1, U1.16, U6.24
SD_D0: R34.1, U1.14, U6.26
SD_D1: R35.1, U1.12, U6.27
SD_D2: R36.1, U1.18, U6.28
SD_D3: R37.1, U1.17, U6.29
SD_DET: R38.1, U1.11
STR1_A: D2.1, R90.2
STR1_M: D2.2, D3.1
STR2_A: D4.1, R91.2
STR2_M: D4.2, D5.1
STR3_A: D6.1, R92.2
STR3_M: D6.2, D7.1
SW_0V9: L1.1, U2.3
SW_WIFI: L5.1, U4.3
USB_DM: J1.A7, J1.B7, U1.26, U10.1, U10.6
USB_DP: J1.A6, J1.B6, U1.27, U10.3, U10.4
USB_VBUSDET: C4.1, R1.2, R2.1, U1.25
VCC_1V8: C19.1, C20.1, C42.1, C43.1, C44.1, C45.1, L4.2, L6.1, L7.1, R11.1, R15.1, R16.1, R23.2, R39.1, R41.2, R42.2, R47.1, U1.53, U1.70
VCC_1V8_ADC: C56.1, R16.2, U1.24
VCC_1V8_CODEC: C57.1, L6.2, U1.31
VCC_1V8_MIPI: C54.1, C55.1, R15.2, U1.1
VCC_1V8_OTP: C59.1, L7.2, U1.96
VCC_3V3: C14.1, C15.1, C16.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C68.1, C69.1, C73.1, C85.1, C86.1, L2.2, L8.1, R7.1, R19.1, R22.2, R27.2, R28.2, R33.2, R34.2, R35.2, R36.2, R37.2, U1.13, U1.28, U1.43, U1.61, U1.81, U1.88, U1.108, U5.8, U7.1, U7.7, U7.8, U9.4, U9.6
VCC_3V3_ETH: C60.1, L8.2, U1.101
VCC_DDR: C17.1, C18.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, L3.2, R9.1, U1.49, U1.50, U1.56
VCC_RTC: C61.1, R19.2, U1.19
VDD_0V9: C6.1, C7.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, L1.2, R3.1, U1.10, U1.51, U1.54, U1.55, U1.67, U1.71, U1.82, U1.103, U1.115, U1.116
VSYS: C1.1, C2.1, C3.1, C5.1, C8.1, C9.1, C10.1, C11.1, C21.1, C87.1, C89.1, C90.1, D1.1, J1.A4B9, J1.B4A9, R1.1, R5.1, R6.1, R90.1, R91.1, R92.1, TP4.1, U2.1, U2.4, U3.7, U3.10, U3.16, U3.19, U4.1, U4.4, U10.5
VWIFI: C22.1, C23.1, C70.1, C71.1, L5.2, R13.1, R30.2, R31.2, U6.3
WIFI_BOOT: R30.1, U1.60, U6.23
WIFI_EN: C72.1, R29.1, U1.74, U6.8
WIFI_HOST_WAKE: U1.62, U6.9
WIFI_IO8: R31.1, U6.22
WIFI_RXD: U1.75, U6.30
WIFI_TXD: U1.76, U6.31
WIFI_USB_DM: TP6.1, U6.17
WIFI_USB_DP: TP7.1, U6.18
XIN_24M: C62.1, R21.1, U1.68, Y1.1
XOUT_24M: R20.1, U1.69
XOUT_24M_X: C63.1, R20.2, R21.2, Y1.3

File products/layercam/layercam-pro/production/layercam-pro-bom-pcbway.csv:

Item #,Designator,Qty,Manufacturer,Manufacturer Part Number,Description,Value,Package/Footprint,Type,LCSC Part #,Digi-Key Part #,Side
1,"R22,R25,R38,R47",4,UNI-ROYAL,0402WGF1001TCE,Resistor 1k 1% 0402,1k,R_0402_1005Metric,SMD,C11702,,Bottom+Top
2,LED1,1,Hubei KENTO,KT-0603G,LED green 0603 (status),green,LED0603-RD,SMD,C12624,,Top
3,"U2,U4",2,Texas Instruments,TLV62569DBVR,"2 A synchronous buck, 0.6 V reference, SOT-23-5, Tj to 125 degC",TLV62569,SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR,SMD,C141836,,Top
4,C66,1,Samsung Electro-Mechanics,CL05B103KB5NNNC,Capacitor 10nF 50V X7R 0402,10nF,C_0402_1005Metric,SMD,C15195,,Top
5,C67,1,FH (Fenghua),0402B102K500NT,Capacitor 1nF 50V X7R 0402,1nF,C_0402_1005Metric,SMD,C1523,,Top
6,"C3,C4,C24,C25,C26,C27,C28,C29,C36,C37,C38,C42,C43,C44,C46,C47,C48,C49,C50,C51,C52,C54,C56,C59,C60,C68,C71,C72,C76,C77,C79,C81,C82,C86,C88,C90",36,Samsung Electro-Mechanics,CL05B104KO5NNNC,Capacitor 100nF 16V X7R 0402,100nF,C_0402_1005Metric,SMD,C1525,,Bottom+Top
7,"C62,C63,C64,C65",4,FH (Fenghua),0402CG180J500NT,Capacitor 18pF 50V C0G 0402,18pF,C_0402_1005Metric,SMD,C1549,,Bottom+Top
8,C6,1,FH (Fenghua),0402CG6R8C500NT,Capacitor 6.8pF 50V C0G 0402,6.8pF,C_0402_1005Metric,SMD,C1576,,Top
9,J3,1,Molex,53261-0271,"PicoBlade 1.25 mm 2 pin, right angle, SMD, -40..105 degC",IR-cut,CONN-SMD_532610271,SMD,C177225,,Bottom
10,"R90,R91,R92",3,UNI-ROYAL,1206W4F470JT5E,Resistor 47R 1% 0.25 W 1206 (IR LED string),47R,R_1206_3216Metric,SMD,C17969,,Bottom
11,C12,1,CCTC,TCC0402X7R334K100AT,Capacitor 330nF 10V X7R 0402,330nF,C_0402_1005Metric,SMD,C18164591,,Top
12,Y2,1,Abracon,ABS07AIG-32.768KHZ-1-T,"Crystal 32.768 kHz 12.5 pF (the SoC's RTC), 3215, -40..125 degC",32.768kHz,FC-135R_L3.2-W1.5,SMD,C1985607,535-ABS07AIG-32.768KHZ-1-TCT-ND,Bottom
13,U6,1,Espressif,ESP32-C6-MINI-1U-H4,"Wi-Fi 6 2.4 GHz + BLE module, ESP32-C6, 4 MB flash, MHF III antenna socket, -40..105 degC",ESP32-C6-MINI-1U-H4,WIFIM-SMD_61P-L13.2-W12.5-P0.80,SMD,C20627095,,Top
14,Q1,1,Alpha & Omega,AO3400A,"N-MOSFET 30 V 5.7 A, logic level, SOT-23 (IR LED switch)",AO3400A,SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR,SMD,C20917,,Bottom
15,"R19,R24,R45",3,UNI-ROYAL,0402WGF1000TCE,Resistor 100R 1% 0402,100R,R_0402_1005Metric,SMD,C25076,,Bottom+Top
16,"R15,R16,R39",3,UNI-ROYAL,0402WGF100KTCE,Resistor 1R 1% 0402,1R,R_0402_1005Metric,SMD,C25086,,Bottom+Top
17,"R20,R26,R32,R40",4,UNI-ROYAL,0402WGF220JTCE,Resistor 22R 1% 0402,22R,R_0402_1005Metric,SMD,C25092,,Bottom+Top
18,R18,1,UNI-ROYAL,0402WGF2400TCE,Resistor 240R 1% 0402,240R,R_0402_1005Metric,SMD,C25094,,Bottom
19,"R4,R5,R7,R10,R12,R13,R29,R43,R44,R46",10,UNI-ROYAL,0402WGF1003TCE,Resistor 100k 1% 0402,100k,R_0402_1005Metric,SMD,C25741,,Bottom+Top
20,"R1,R23,R27,R28,R30,R31,R33,R34,R35,R36,R37",11,UNI-ROYAL,0402WGF1002TCE,Resistor 10k 1% 0402,10k,R_0402_1005Metric,SMD,C25744,,Bottom+Top
21,R9,1,UNI-ROYAL,0402WGF1273TCE,Resistor 127k 1% 0402,127k,R_0402_1005Metric,SMD,C25751,,Top
22,R2,1,UNI-ROYAL,0402WGF1802TCE,Resistor 18k 1% 0402,18k,R_0402_1005Metric,SMD,C25762,,Bottom
23,"R6,R11",2,UNI-ROYAL,0402WGF2003TCE,Resistor 200k 1% 0402,200k,R_0402_1005Metric,SMD,C25764,,Top
24,R48,1,UNI-ROYAL,0402WGF2202TCE,Resistor 22k 1% 0402,22k,R_0402_1005Metric,SMD,C25768,,Bottom
25,R3,1,UNI-ROYAL,0402WGF5102TCE,Resistor 51k 1% 0402,51k,R_0402_1005Metric,SMD,C25794,,Top
26,"R41,R42",2,UNI-ROYAL,0402WGF4701TCE,Resistor 4.7k 1% 0402,4.7k,R_0402_1005Metric,SMD,C25900,,Top
27,"R49,R50",2,UNI-ROYAL,0402WGF5101TCE,Resistor 5.1k 1% 0402,5.1k,R_0402_1005Metric,SMD,C25905,,Top
28,R17,1,UNI-ROYAL,0402WGF6201TCE,Resistor 6.2k 1% 0402,6.2k,R_0402_1005Metric,SMD,C25915,,Top
29,R21,1,UNI-ROYAL,0402WGF1004TCE,Resistor 1M 1% 0402,1M,R_0402_1005Metric,SMD,C26083,,Top
30,"R8,R14",2,UNI-ROYAL,0402WGF2262TCE,Resistor 22.6k 1% 0402,22.6k,R_0402_1005Metric,SMD,C26960,,Top
31,U9,1,Texas Instruments,TLV75528PDRVR,"LDO 2.8 V 500 mA, low noise (the sensor's analogue supply), WSON-6 2 x 2, Tj to 125 degC",2.8V,WSON-6_L2.0-W2.0-P0.65-BL-EP,SMD,C2865214,,Top
32,U5,1,Winbond,W25N02KVZEIR,"SPI NAND flash 2 Gbit (256 MB), 3.3 V, WSON-8 8 x 6",W25N02KV,WSON-8_L8.0-W6.0-P1.27-TL-EP-1,SMD,C3010298,,Top
33,J1,1,GCT,USB4105-GF-A,"USB-C receptacle, USB 2.0, 1.6 mm board, -40..85 degC",USB-C,USB-C_SMD-TYPE-C-31-M-12_1,SMD,C3020560,,Top
34,D1,1,Jingdao,SMF6.0CA,"TVS 6 V stand-off, bidirectional, 200 W, SOD-123FL",SMF6.0CA,SOD-123FL_L2.8-W1.8-LS3.7-BI,SMD,C353271,,Top
35,"C14,C17,C19",3,FH (Fenghua),0402CG221J500NT,Capacitor 220pF 50V C0G 0402,220pF,C_0402_1005Metric,SMD,C39122,,Bottom+Top
36,"C7,C15,C16,C18,C20,C22,C23,C70",8,Murata,GRM188C80J226ME15D,Capacitor 22uF 6.3V X6S 0603,22uF,C_0603_1608Metric,SMD,C393031,,Bottom+Top
37,Y1,1,ECS,ECS-240-12-33Q-JES-TR,"Crystal 24 MHz 12 pF, 3225, -40..125 degC",24MHz,CRYSTAL-SMD_4P-L3.2-W2.5-BL,SMD,C435181,XC2150CT-ND,Top
38,"C11,C30,C31,C32,C39,C45,C55,C57,C61,C69,C73,C74,C75,C78,C85",15,Murata,GRM155C71A105KE11D,Capacitor 1uF 10V X7S 0402,1uF,C_0402_1005Metric,SMD,C437522,,Bottom+Top
39,"C83,C84",2,Murata,GRM155C80J225KE95D,Capacitor 2.2uF 6.3V X6S 0402,2.2uF,C_0402_1005Metric,SMD,C521077,,Bottom
40,U7,1,Texas Instruments,DRV8210PDSGR,"H-bridge, for the IR-cut filter, WSON-8 2 x 2, -40..125 degC",DRV8210P,WSON-8_L2.0-W2.0-P0.50-TL-EP,SMD,C5218852,296-DRV8210PDSGRCT-ND,Bottom
41,U1,1,Rockchip,RV1106G3,"Camera SoC: Cortex-A7 1.2 GHz, 256 MB DDR3L inside, ISP, H.264/H.265, QFN-128 0.35 mm",RV1106G3,QFN-128_L12.3-W12.3-P0.35-TL-EP7.0-1,SMD,C5328706,,Top
42,C13,1,CCTC,TCC0402X7R474K100AT,Capacitor 470nF 10V X7R 0402,470nF,C_0402_1005Metric,SMD,C5448817,,Top
43,U3,1,Everanalog,EA3036CQBR,"Triple 1 A synchronous buck, 2.7-5.5 V in, WQFN-20 3 x 3",EA3036C,WQFN-20_L3.0-W3.0-P0.40-BL-EP,SMD,C570857,,Top
44,"L1,L5",2,Murata,DFE252012F-2R2M=P2,"Inductor 2.2 uH 2.3 A sat, 2520",2.2uH,IND-SMD_L2.5-W2.0,SMD,C576403,490-13055-1-ND,Top
45,"C1,C2,C5,C8,C9,C10,C21,C33,C34,C35,C40,C41,C53,C87,C89",15,Murata,GRM188C81A106MA73D,Capacitor 10uF 10V X6S 0603,10uF,C_0603_1608Metric,SMD,C576470,,Bottom+Top
46,"D2,D3,D4,D5,D6,D7",6,Vishay,VSMY3850X01-GS08,"IR LED 850 nm, 100 mA, +-60 degrees, PLCC-2 3.5 x 2.8, -40..105 degC (pad 1 anode)",850nm,LED_PLCC2_VSMY3850,SMD,C6925914,,Bottom
47,"C58,C80",2,Taiyo Yuden,JMK105BC6475MV-F,Capacitor 4.7uF 6.3V X6S 0402,4.7uF,C_0402_1005Metric,SMD,C697614,,Bottom+Top
48,U10,1,STMicroelectronics,USBLC6-2SC6,"USB ESD protection, SOT-23-6",USBLC6-2SC6,SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL,SMD,C7519,,Top
49,"L6,L7,L8",3,Murata,BLM15PD121SN1D,"Ferrite bead 120 ohm at 100 MHz, 1.3 A, 0402",120R@100MHz,L_0402_1005Metric,SMD,C76891,,Top
50,"L2,L3,L4",3,Murata,DFE252012F-1R5M=P2,"Inductor 1.5 uH 2.7 A sat, 2520",1.5uH,IND-SMD_L2.5-W2.0,SMD,C909806,490-13054-1-ND,Top
51,Q2,1,Vishay,TEMT6000X01,"Ambient light phototransistor, eye response (blind to the 850 nm LEDs), -40..100 degC",TEMT6000,SENSORS-SMD_TEMT6000X01,SMD,C94098,,Bottom
52,U8,1,SmartSens,SC4336H,"Image sensor 4 MP 1/3"", 2-lane MIPI, CSP-35 0.64 x 0.58 mm, -30..85 degC",SC4336H,CSP-35_L5.7-W3.7-P0.64-R5-C7-S0.58-TL,SMD,none: SmartSens or its agent,,Bottom

## KiCad design products/layercam/layercam/ring/layercam-ring.kicad_pcb

Board: 2 copper layers, 33.0 x 33.0 mm, 11 parts (4 on the bottom side), 10 nets.

Parts:
D1, D2, D3, D4, D5, D6: 850nm; LED-SMD_L3.5-W2.8-R-RD_RED-1
J1: SH 6; CONN-SMD-6P-P1.00_BM06B-SRSS-TB-LF-SN
Q1: TEMT6000; SENSORS-SMD_TEMT6000X01
R1, R2, R3: 47R; R_1206_3216Metric

Connections:
ALS: J1.4, Q1.1, Q1.2
ALS_VCC: J1.3, Q1.3
LED_K: D2.2, D4.2, D6.2, J1.2, J1.5
STR1_A: D1.1, R1.2
STR1_M: D1.2, D2.1
STR2_A: D3.1, R2.2
STR2_M: D3.2, D4.1
STR3_A: D5.1, R3.2
STR3_M: D5.2, D6.1
VSYS: J1.1, J1.6, R1.1, R2.1, R3.1
